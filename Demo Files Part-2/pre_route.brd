# Allegro board pre_route.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 208.91,200.91 207.14,200.91 207.01,200.79 207.01,197.87 207.14,197.74 208.91,197.74 208.91,197.36 207.14,197.36 207.01,197.23 207.01,194.18 207.14,194.06 209.04,194.06 209.04,193.67 207.14,193.67 207.01,193.55 207.01,190.63 207.26,190.37 209.04,190.37 209.04,189.99 207.14,189.99 206.63,189.48 206.12,189.48 205.99,189.61 205.99,201.04 206.25,201.29 208.91,201.29
GND on TOP (solid shape): 158.62,211.84 158.62,203.58 158.5,203.45 151.82,203.45 151.69,203.58 151.69,206.57 151.69,209.29 151.84,209.29 151.84,206.57 152.96,206.57 152.96,208.09 154.32,208.09 154.32,208 155.89,208 157.61,208 157.61,209.32 155.89,209.32 154.32,209.32 154.32,209.23 152.96,209.23 152.96,209.29 151.69,209.29 151.69,210.49 153.16,211.96 158.5,211.96
GND on TOP (solid shape): 137.41,280.67 137.41,273.99 137.29,273.86 134.3,273.86 131.58,273.86 130.38,273.86 128.91,275.34 128.91,278.07 131.55,278.07 131.55,276.49 131.64,276.49 131.64,275.13 131.58,275.13 131.58,274.02 134.3,274.02 134.3,275.13 132.78,275.13 132.78,276.49 132.87,276.49 132.87,278.07 132.87,279.78 131.55,279.78 131.55,278.07 128.91,278.07 128.91,280.67 129.03,280.8 137.29,280.8
GND on TOP (solid shape): 131.32,267.46 131.32,266.7 131.58,266.44 131.58,266.4 131.62,266.4 132.08,265.94 135.38,265.94 135.89,265.43 135.89,261.62 134.87,260.6 124.21,260.6 123.82,260.99 123.82,264.67 125.41,264.67 125.41,262.13 126.56,262.13 126.56,264.19 127.41,265.05 127.48,265.02 130.3,265.02 131.29,264.03 131.58,264.03 131.58,263.86 134.3,263.86 134.3,264.97 131.54,264.97 131.46,264.94 130.8,265.6 130.8,266.34 129.22,266.34 129.22,265.02 129.1,265.02 129.1,266.34 127.52,266.34 127.52,266.07 127.35,266.07 125.95,264.67 123.82,264.67 123.82,267.21 124.59,267.97 130.81,267.97
GND on TOP (solid shape): 145.8,216.28 145.8,210.06 145.29,209.55 144.53,209.55 144.27,209.29 144.22,209.29 144.22,209.25 143.76,208.79 143.76,205.49 143.26,204.98 139.45,204.98 138.43,205.99 138.43,209.29 141.68,209.29 141.68,206.57 142.8,206.57 142.8,209.33 142.77,209.41 143.43,210.07 144.17,210.07 144.17,211.65 142.85,211.65 142.85,210.57 141.86,209.58 141.86,209.29 138.43,209.29 138.43,214.31 142.02,214.31 142.88,213.45 142.85,213.39 142.85,211.77 144.17,211.77 144.17,213.35 143.89,213.35 143.89,213.52 142.49,214.91 142.49,215.46 139.95,215.46 139.95,214.31 138.43,214.31 138.43,216.66 138.81,217.04 145.03,217.04
GND on TOP (solid shape): outline of 84 points within 27.05,101.22 51.69,105.66
GND on BOTTOM (solid shape): 52.96,201.42 52.96,196.98 52.32,196.34 45.34,196.34 44.7,196.98 44.7,201.42 45.34,202.06 52.32,202.06
GND on BOTTOM (solid shape): 88.52,288.16 88.52,285.75 87.88,285.12 85.09,285.12 84.45,285.75 84.45,288.29 84.96,288.8 87.88,288.8
GND on BOTTOM (solid shape): 71.37,197.61 71.37,190.63 70.74,189.99 63.75,189.99 63.12,190.63 63.12,197.61 63.75,198.25 70.74,198.25
GND on BOTTOM (solid shape): 174.37,214.5 173.1,214.5 172.72,214.12 171.83,214.12 171.7,214.25 171.7,217.3 171.83,217.42 174.37,217.42
GND on BOTTOM (solid shape): 54.86,237.62 54.86,229.36 54.23,228.73 43.05,228.73 42.8,228.98 42.8,237.62 43.43,238.25 54.23,238.25
GND on BOTTOM (solid shape): 87.76,275.21 87.76,272.03 87.12,271.4 85.09,271.4 84.45,272.03 84.45,274.96 85.34,275.84 87.12,275.84
GND on BOTTOM (solid shape): 87.76,259.97 87.76,256.79 87.12,256.16 85.09,256.16 84.45,256.79 84.45,259.72 85.34,260.6 87.12,260.6
GND on BOTTOM (solid shape): 173.1,249.81 174.37,249.81 174.37,246.89 173.1,246.89 172.21,246 171.96,246 171.7,246.25 171.7,250.44 171.83,250.57 172.34,250.57
GND on BOTTOM (solid shape): 173.1,239.65 174.37,239.65 174.37,236.73 173.1,236.73 172.21,235.84 171.96,235.84 171.7,236.09 171.7,240.28 171.83,240.41 172.34,240.41
GND on BOTTOM (solid shape): 173.1,223.14 174.37,223.14 174.37,220.22 173.1,220.22 172.21,219.33 171.96,219.33 171.7,219.58 171.7,223.77 171.83,223.9 172.34,223.9
GND on BOTTOM (solid shape): 173.1,212.98 174.37,212.98 174.37,210.06 173.1,210.06 172.21,209.17 171.96,209.17 171.7,209.42 171.7,213.61 171.83,213.74 172.34,213.74
GND on BOTTOM (solid shape): 173.1,193.93 174.37,193.93 174.37,191.01 173.1,191.01 172.21,190.12 171.96,190.12 171.7,190.37 171.7,194.56 171.83,194.69 172.34,194.69
GND on BOTTOM (solid shape): 173.1,183.77 174.37,183.77 174.37,180.85 173.1,180.85 172.21,179.96 171.96,179.96 171.7,180.21 171.7,184.4 171.83,184.53 172.34,184.53
GND on BOTTOM (solid shape): 173.1,167.26 174.37,167.26 174.37,164.34 173.1,164.34 172.21,163.45 171.96,163.45 171.7,163.7 171.7,167.89 171.83,168.02 172.34,168.02
GND on BOTTOM (solid shape): 87.76,244.73 87.76,239.52 87.12,238.89 85.09,238.89 84.45,239.52 84.45,244.47 85.34,245.36 87.12,245.36
GND on BOTTOM (solid shape): 173.1,176.15 174.37,176.15 174.37,169.42 174.24,169.29 173.1,169.29 172.34,168.53 171.7,168.53 171.58,168.66 171.58,176.78 171.7,176.91 172.34,176.91
GND on BOTTOM (solid shape): 170.31,267.72 170.31,240.79 170.18,240.66 167,240.66 165.48,242.19 155.45,242.19 154.69,242.95 154.69,262.51 155.32,263.14 161.67,263.14 161.92,263.4 161.92,266.7 162.31,267.08 162.69,267.08 163.07,266.7 163.07,263.4 163.32,263.14 168.4,263.14 168.91,263.65 168.91,267.72 169.16,267.97 170.05,267.97
GND on BOTTOM (solid shape): 174.37,156.34 174.37,151.89 174.62,151.64 175.01,151.64 175.13,151.51 175.13,150.75 175.01,150.62 174.62,150.62 174.37,150.37 174.37,149.35 174.62,149.1 175.01,149.1 175.13,148.97 175.13,148.21 175.01,148.08 174.75,148.08 174.37,147.7 174.37,144.14 174.5,144.02 174.88,144.02 175.13,143.76 175.13,143.26 174.88,143 174.5,143 174.24,142.75 174.24,138.81 174.37,138.68 175.01,138.68 175.13,138.56 175.13,138.05 175.01,137.92 173.1,137.92 172.97,138.05 172.97,155.7 172.85,155.83 170.43,155.83 170.31,155.96 170.31,156.46 170.43,156.59 174.12,156.59
GND on L2_GND1 (solid shape): outline of 5497 points within 0.64,0.64 329.56,304.16
GND_HSSI on TOP (solid shape): 309.76,215.78 321.8,215.78 330.26,215.78 330.26,199.53 326.8,199.52 306.78,199.53 287.96,199.53 287.96,204.21 288.96,204.21 288.96,201.53 303.45,201.53 303.45,213.78 288.96,213.78 288.96,211.1 287.96,211.1 287.96,215.78 301.8,215.78
GND_HSSI on TOP (solid shape): 309.76,195.46 321.8,195.46 330.26,195.46 330.26,179.21 326.8,179.2 306.78,179.21 287.96,179.21 287.96,183.89 288.96,183.89 288.96,181.21 303.45,181.21 303.45,193.46 288.96,193.46 288.96,190.78 287.96,190.78 287.96,195.46 301.8,195.46
GND_HSSI on TOP (solid shape): 309.76,175.14 321.8,175.14 330.26,175.14 330.26,158.89 326.8,158.88 306.78,158.89 287.96,158.89 287.96,163.57 288.96,163.57 288.96,160.89 303.45,160.89 303.45,173.14 288.96,173.14 288.96,170.46 287.96,170.46 287.96,175.14 301.8,175.14
GND_HSSI on TOP (solid shape): 309.76,154.82 321.8,154.82 330.26,154.82 330.26,138.57 326.8,138.56 306.78,138.57 287.96,138.57 287.96,143.25 288.96,143.25 288.96,140.57 303.45,140.57 303.45,152.82 288.96,152.82 288.96,150.14 287.96,150.14 287.96,154.82 301.8,154.82
GND_HSSI on TOP (solid shape): 76.58,269.24 76.58,255.27 75.69,254.38 58.8,254.38 57.79,253.36 57.79,247.52 56.58,246.32 50.23,246.32 47.24,249.3 47.24,255.14 47.62,255.52 50.55,255.52 51.31,256.29 51.31,261.37 51.05,261.62 47.75,261.62 47.37,262 47.37,262.38 47.75,262.76 51.05,262.76 51.31,263.02 51.31,269.37 51.82,269.88 75.95,269.88
GND_HSSI on TOP (solid shape): outline of 314 points within 307.09,273.81 330.07,288.8
GND_HSSI on TOP (solid shape): outline of 313 points within 307.09,256.67 330.07,271.65
GND_HSSI on TOP (solid shape): outline of 314 points within 307.09,239.52 330.07,254.51
GND_HSSI on TOP (solid shape): outline of 313 points within 307.09,222.38 330.07,237.36
GND_HSSI on TOP (solid shape): outline of 645 points within 317.47,13.46 332.11,137.16
GND_HSSI on TOP (solid shape): outline of 727 points within 269.88,10.79 308.61,101.6
GND_HSSI on TOP (solid shape): outline of 689 points within 244.6,237.36 293.88,260.73
GND_HSSI on BOTTOM (solid shape): outline of 431 points within 318.72,13.46 332.11,136.49
GND_HSSI on L2_GND1 (solid shape): 232.73,231.06 232.73,225.22 233.47,224.47 244.87,224.47 245.19,224.79 245.73,224.79 246.05,224.47 247.27,224.47 248.16,223.58 248.16,218.82 248.79,218.19 251.21,218.19 251.46,218.44 251.46,224.16 251.78,224.47 256.97,224.47 257.43,224.01 257.43,211.41 256.59,210.57 250.78,210.57 250.51,210.84 250.51,215.15 250.14,215.52 246.71,215.52 246.51,215.72 246.51,216.11 246.08,216.54 231.57,216.54 231.14,216.11 231.14,215.66 231,215.52 229.76,215.52 229.43,215.85 229.43,216.23 229.12,216.54 227.57,216.54 227.2,216.17 227.2,210.77 227,210.57 223.54,210.57 223.39,210.71 223.39,211.79 222.44,212.74 222.44,218.9 221.17,220.17 221.17,223.7 222.44,224.97 222.44,227.15 221.17,228.42 221.17,230.81 221.88,231.52 232.27,231.52
GND_HSSI on L2_GND1 (solid shape): outline of 306 points within 173.36,285.75 204.22,304.16
GND_HSSI on L2_GND1 (solid shape): outline of 636 points within 287.02,138.3 329.56,216.03
GND_HSSI on L4_IS2 (solid shape): outline of 430 points within 317.5,13.45 332.11,136.49
GND_HSSI on L4_IS2 (solid shape): outline of 1488 points within 305.43,220.6 330.28,290.32
GND_HSSI on L4_IS2 (solid shape): outline of 3394 points within 168.4,258.5 239.47,303.68
GND_HSSI on L4_IS2 (solid shape): outline of 5837 points within 228.47,210.44 246.63,227.71
GND_HSSI on L6_IS3 (solid shape): 231.2,227.14 231.2,220.41 231.84,219.77 231.84,219.01 231.9,218.95 231.9,218.76 231.84,218.69 231.84,218.57 231.33,218.06 231.33,217.42 231.2,217.3 230.45,217.3 230.33,217.42 230.33,217.85 230.19,218.19 229.84,218.34 229.5,218.2 229.36,217.86 229.36,217.42 229.23,217.3 228.98,217.3 228.85,217.42 228.85,217.68 228.79,217.74 228.79,217.93 228.85,218 228.85,218.69 228.79,218.76 228.79,218.95 228.85,219.01 228.85,219.27 228.93,219.34 229.83,219.34 229.84,219.34 230.2,219.49 230.35,219.85 230.35,219.87 230.46,220.9 230.45,220.94 230.3,221.29 229.95,221.44 229.93,221.44 229.29,221.44 229.17,221.55 229.17,226.24 229.24,226.24 229.26,226.22 230.11,226.57 229.26,226.91 229.24,226.9 229.17,226.9 229.17,227.52 229.36,227.71 230.63,227.71
GND_HSSI on L6_IS3 (solid shape): outline of 1181 points within 233.36,211.58 239.71,227.71
GND_HSSI on L6_IS3 (solid shape): outline of 1288 points within 239.77,211.58 246.76,227.71
GND_HSSI on L6_IS3 (solid shape): outline of 3359 points within 168.02,258.5 239.47,303.68
GND_HSSI on L9_IS5 (solid shape): outline of 732 points within 239.71,215.26 266.7,226.69
GND_HSSI on L10_IS6 (solid shape): outline of 1346 points within 223.44,237.36 313.06,290.98
GND_HSSI on L10_IS6 (solid shape): outline of 1640 points within 269.88,10.79 308.61,129.54
GND_HSSI on L14_GND3 (solid shape): outline of 6940 points within 0.64,0.64 329.56,304.16
GND_HSSI on L16_IS10 (solid shape): outline of 737 points within 172.72,85.09 189.48,101.6
GND_HSSI on L16_IS10 (solid shape): outline of 1309 points within 170.18,41.27 205.74,68.58
GND_HSSI on L16_IS10 (solid shape): outline of 1319 points within 229.29,214.25 250.39,216.08
GND_HSSI on L17_PWR3 (solid shape): outline of 2038 points within 172.66,0.64 329.56,304.16
GND_PLL on L8_GND2 (solid shape): outline of 7299 points within 0.64,0.64 329.56,304.16
GND_PLL on L17_PWR3 (solid shape): 221.66,205.04 223.09,205.04 223.58,205.53 223.58,206.04 223.73,206.18 225.09,206.18 225.23,206.04 225.23,203.15 224.22,202.14 224.22,201.75 223.95,201.49 223.6,201.49 223.46,201.63 223.46,202.26 223.09,202.63 220.8,202.63 219.53,203.9 212.65,203.9 211.5,202.76 209.22,202.76 206.95,200.48 206.95,195.4 204.15,192.61 204.15,179.5 206.95,176.71 206.95,150.7 205.68,149.43 205.68,137.84 206.31,137.21 206.31,133.17 204.65,131.51 196.88,131.51 196.56,131.19 195.83,131.19 195.77,131.25 195.77,132.64 196.15,133.02 196.15,135.19 197.18,135.19 199.6,137.6 201.25,137.6 202.76,139.11 202.76,149.65 203.64,150.54 203.64,176.23 200.85,179.02 200.85,184.96 201.49,185.6 201.49,194.23 203.26,196.01 203.26,202.49 207.03,206.25 207.26,206.25 207.39,206.12 207.39,204.85 207.77,204.47 209.42,204.47 210.44,205.49 210.44,206.76 210.88,207.2 219.5,207.2
GND_RTN on BOTTOM (solid shape): 91.06,236.6 91.06,230 100.33,220.73 100.33,218.95 91.06,209.68 91.06,198.37 96.39,193.04 99.69,193.04 101.73,195.07 111.63,195.07 112.08,194.63 118.68,194.63 119,194.31 120.02,194.31 123.19,191.13 123.19,188.59 118.62,184.02 104.65,184.02 102.87,182.25 91.19,182.25 83.44,189.99 83.44,236.22 84.71,237.49 90.17,237.49
VCCA on BOTTOM (solid shape): 23.49,139.7 23.49,135.89 22.23,134.62 18.92,134.62 18.03,135.51 18.03,139.45 18.54,139.95 23.24,139.95
VCCQP on TOP (solid shape): 144.65,265.43 145.8,265.43 146.05,265.18 146.05,263.65 145.8,263.4 144.4,263.4 143.38,264.41 143.38,264.8 143.13,265.05 140.84,265.05 140.72,265.18 140.72,266.19 140.84,266.32 143.76,266.32
VCCQP on BOTTOM (solid shape): 144.65,265.56 147.19,265.56 148.59,264.16 148.59,263.14 148.34,262.89 146.3,262.89 145.8,262.38 141.35,262.38 141.22,262.51 141.22,263.14 143.27,263.14 143.27,263.11 143.28,263.05 143.29,262.99 143.32,262.93 143.35,262.87 143.39,262.82 143.43,262.78 143.48,262.74 143.53,262.7 143.59,262.68 143.65,262.66 143.72,262.65 143.78,262.65 143.84,262.65 143.91,262.67 143.96,262.69 144.02,262.72 144.07,262.76 144.12,262.8 144.16,262.85 144.2,262.9 144.22,262.96 144.24,263.02 144.26,263.08 144.26,263.14 144.26,263.21 144.24,263.27 144.22,263.33 144.2,263.39 144.16,263.44 144.12,263.49 144.07,263.53 144.02,263.57 143.96,263.6 143.91,263.62 143.84,263.63 143.78,263.64 143.72,263.64 143.65,263.63 143.59,263.61 143.53,263.58 143.48,263.55 143.43,263.51 143.39,263.47 143.35,263.41 143.32,263.36 143.29,263.3 143.28,263.24 143.27,263.18 143.27,263.14 141.22,263.14 141.22,265.68 141.48,265.94 144.27,265.94
APS on BOTTOM (solid shape): 306.07,123.82 306.07,110.49 303.53,107.95 286.39,107.95 284.61,109.73 271.65,109.73 270.76,108.84 258.7,108.84 257.43,110.11 257.43,112.14 258.19,112.9 277.5,112.9 277.88,112.52 291.97,112.52 292.99,111.51 297.81,111.51 298.45,112.14 298.45,118.11 299.21,118.87 302.01,118.87 302.39,119.25 302.39,124.08 302.77,124.46 305.44,124.46
APS_INPUT on BOTTOM (solid shape): 259.59,138.56 259.59,137.41 258.19,136.02 257.05,136.02 256.92,136.14 256.92,138.56 257.05,138.68 259.46,138.68
APS_INPUT on BOTTOM (solid shape): outline of 84 points within 277.5,113.03 292.8,129.29
BST on BOTTOM (solid shape): 289.81,123.32 289.81,121.92 289.56,121.67 286.58,121.67 286,122.24 286,122.87 286.13,123 288.48,123 288.93,123.44 289.69,123.44
NET_2_I2_1 on TOP (solid shape): 85.72,268.48 85.72,263.53 85.09,262.89 81.66,262.89 81.03,263.53 81.03,268.61 81.79,269.37 84.84,269.37
NET_2_I2_1 on BOTTOM (solid shape): 85.72,267.46 85.72,261.75 83.95,259.97 83.95,257.68 83.57,257.3 81.41,257.3 81.03,257.68 81.03,268.1 85.09,268.1
NET_2_I17_1 on TOP (solid shape): 85.72,283.72 85.72,278.77 85.09,278.13 81.66,278.13 81.03,278.77 81.03,283.85 81.79,284.61 84.84,284.61
NET_2_I17_1 on BOTTOM (solid shape): 85.72,282.7 85.72,276.99 83.95,275.21 83.95,272.92 83.57,272.54 81.41,272.54 81.03,272.92 81.03,283.34 85.09,283.34
NET_2_I21_2 on BOTTOM (solid shape): 135,268.48 135,267.34 135.38,266.95 139.83,266.95 140.21,266.57 140.21,264.03 138.05,261.87 138.05,258.06 136.78,256.79 132.33,256.79 131.44,257.68 131.44,265.94 131.83,266.32 133.86,266.32 134.04,266.5 134.04,268.48 134.16,268.61 134.87,268.61
NET_2_I22_2 on BOTTOM (solid shape): 133.99,272.29 133.99,269.88 133.6,269.49 131.06,269.49 129.41,271.15 129.41,272.92 130.18,273.69 132.59,273.69
NET_2_I31_2 on BOTTOM (solid shape): 52.96,194.44 52.96,190.63 52.32,189.99 45.34,189.99 44.7,190.63 44.7,194.44 45.34,195.07 52.32,195.07
NET_2_I41_1 on TOP (solid shape): 85.72,253.24 85.72,248.28 85.09,247.65 81.66,247.65 81.03,248.28 81.03,253.36 81.79,254.13 84.84,254.13
NET_2_I41_1 on BOTTOM (solid shape): 85.72,252.22 85.72,246.51 83.95,244.73 83.95,242.19 83.69,241.94 81.28,241.94 81.03,242.19 81.03,252.86 85.09,252.86
NET_2_I149_IN on TOP (solid shape): 102.74,276.99 107.06,276.99 107.06,272.67 106.3,271.91 102.36,271.91 101.47,271.02 101.47,269.88 100.96,269.37 93.6,269.37 90.68,272.29 90.68,276.86 93.85,280.04 99.69,280.04
NET_2_I149_IN on BOTTOM (solid shape): 101.47,276.73 101.47,272.29 98.55,269.37 92.33,269.37 90.68,271.02 90.68,276.61 91.19,277.11 91.19,283.34 94.87,283.34
NET_2_I150_IN on TOP (solid shape): 101.6,248.92 101.6,247.65 102.74,246.51 107.06,246.51 107.06,242.19 103.76,238.89 93.6,238.89 90.68,241.81 90.68,246.38 93.85,249.56 100.96,249.56
NET_2_I150_IN on BOTTOM (solid shape): 101.47,246.25 101.47,241.81 98.55,238.89 93.34,238.89 90.55,241.68 90.55,246.38 91.19,247.01 91.19,252.86 94.87,252.86
NET_3_I10_2 on TOP (solid shape): 151.13,299.72 151.13,295.91 147.32,292.1 146.05,292.1 144.78,290.83 144.78,285.75 144.14,285.12 141.6,285.12 140.34,283.85 135.25,283.85 134.62,284.48 134.62,287.02 139.06,291.47 139.06,299.09 140.97,300.99 149.86,300.99
NET_3_I10_2 on BOTTOM (solid shape): 141.6,288.29 141.6,285.12 140.34,283.85 135.25,283.85 134.62,284.48 134.62,287.02 136.53,288.93 140.97,288.93
NET_3_I14_ADJ on BOTTOM (solid shape): 168.34,269.05 168.34,264.35 168.15,264.16 165.23,264.16 165.16,264.22 165.16,269.05 165.35,269.24 168.15,269.24
NET_3_I15_2 on BOTTOM (solid shape): 138.56,209.42 143.76,209.42 144.14,209.04 144.14,207.01 144.32,206.83 146.3,206.83 146.43,206.71 146.43,205.99 146.3,205.87 145.16,205.87 144.78,205.49 144.78,201.04 144.4,200.66 141.86,200.66 139.7,202.82 135.89,202.82 134.62,204.09 134.62,209.04 135.13,209.55 138.43,209.55
NET_3_I16_1 on TOP (solid shape): 165.1,299.09 165.1,292.1 168.28,288.93 168.28,284.48 167.51,283.72 165.86,283.72 163.19,286.39 160.66,286.39 159.38,287.66 159.38,290.83 158.11,292.1 156.84,292.1 153.03,295.91 153.03,299.72 154.31,300.99 163.19,300.99
NET_3_I16_1 on BOTTOM (solid shape): 167.64,286.39 167.64,284.23 167.26,283.85 163.96,283.85 162.94,284.86 162.94,288.29 165.73,288.29
NET_3_I17_IN on TOP (solid shape): 137.79,299.72 137.79,292.1 135,289.31 128.02,289.31 127,288.29 121.28,288.29 120.65,288.93 120.65,299.72 121.28,300.36 127,300.36 128.27,301.62 135.89,301.62
NET_3_I22_1 on TOP (solid shape): 95.25,299.72 95.25,288.93 94.61,288.29 89.53,288.29 88.58,289.24 80.96,289.24 78.1,292.1 78.1,297.81 80.64,300.36 94.61,300.36
NET_3_I22_2 on TOP (solid shape): 107.31,296.55 107.31,289.56 106.68,288.93 102.23,288.93 102.23,294.64 102.87,295.28 102.87,296.55 103.5,297.18 106.68,297.18
NET_3_I22_2 on BOTTOM (solid shape): 106.68,292.74 106.68,289.56 105.41,288.29 102.23,288.29 101.6,288.93 101.6,292.74 102.23,293.37 106.04,293.37
NET_3_I33_VCCQP on TOP (solid shape): 144.14,200.03 144.14,197.1 143.26,196.22 143.26,195.33 143.51,195.07 143.51,192.02 142.88,191.39 142.24,191.39 141.6,192.02 141.6,193.29 141.1,193.8 141.1,196.34 141.99,197.23 142.49,197.23 142.88,197.61 142.88,200.03 143,200.15 144.02,200.15
NET_3_I33_VCCQP on BOTTOM (solid shape): 143.51,197.74 144.14,197.1 143.38,196.34 143.38,194.44 142.88,193.93 141.6,193.93 141.1,194.44 141.1,196.34 141.6,196.85 141.6,199.26 141.99,199.64 143.51,199.64
NET_3_I34_1 on TOP (solid shape): 130.94,205.74 130.94,198.88 131.57,198.25 132.84,198.25 133.99,197.1 133.99,193.29 131.44,190.75 127,190.75 126.36,191.39 126.36,202.56 126.62,202.82 126.62,204.09 126.36,204.34 126.36,205.99 127,206.63 130.05,206.63
NET_3_I34_1 on BOTTOM (solid shape): 138.43,197.74 138.43,192.02 137.79,191.39 132.08,191.39 130.81,190.12 128.27,190.12 127.63,190.75 127.63,197.74 128.27,198.37 137.79,198.37
NET_3_I37_2 on TOP (solid shape): 113.03,295.91 113.03,294.64 113.66,294 113.66,288.93 109.22,288.93 108.58,289.56 108.58,296.55 109.22,297.18 111.76,297.18
NET_3_I37_2 on BOTTOM (solid shape): 114.3,292.74 114.3,288.93 113.66,288.29 110.49,288.29 109.22,289.56 109.22,292.74 109.85,293.37 113.66,293.37
NET_3_I56_1 on TOP (solid shape): 136.65,229.74 136.65,207.26 136.02,206.63 134.62,206.63 133.99,205.99 133.99,204.72 134.24,204.47 136.53,204.47 136.53,200.91 135.89,200.28 132.08,200.28 131.44,200.91 131.44,205.99 125.09,212.34 125.09,216.53 124.46,217.17 124.46,227.97 124.47,227.97 124.47,229.88 125.09,230.5 135.89,230.5
NET_3_I121_2 on BOTTOM (solid shape): 151.51,210.69 151.51,208.28 149.86,206.63 147.95,206.63 147.32,207.26 147.32,209.8 148.59,211.07 151.13,211.07
NET_4_I17_1 on TOP (solid shape): 150.75,272.54 150.75,270 151.64,269.11 151.64,264.67 147.83,264.67 147.83,268.99 148.97,270.13 148.97,272.67 149.22,272.92 150.37,272.92
NET_4_I18_1 on TOP (solid shape): 158.75,257.81 158.75,248.92 158.11,248.28 151.76,248.28 151.13,248.92 151.13,254 149.86,255.27 149.86,257.18 150.5,257.81 151.76,257.81 152.4,258.44 158.11,258.44
NET_4_I18_1 on TOP (solid shape): 161.16,278.38 161.16,274.07 158.11,274.07 157.61,274.57 157.61,277.37 157.23,277.75 157.23,277.88 159.91,277.88 159.91,277.84 159.91,277.78 159.93,277.72 159.95,277.66 159.99,277.61 160.02,277.55 160.07,277.51 160.12,277.47 160.17,277.44 160.23,277.41 160.29,277.39 160.35,277.38 160.42,277.38 160.48,277.39 160.54,277.4 160.6,277.42 160.66,277.45 160.71,277.49 160.76,277.53 160.8,277.58 160.83,277.63 160.86,277.69 160.88,277.75 160.89,277.81 160.9,277.88 160.89,277.94 160.88,278 160.86,278.06 160.83,278.12 160.8,278.17 160.76,278.22 160.71,278.26 160.66,278.3 160.6,278.33 160.54,278.35 160.48,278.37 160.42,278.37 160.35,278.37 160.29,278.36 160.23,278.34 160.17,278.32 160.12,278.28 160.07,278.24 160.02,278.2 159.99,278.15 159.95,278.09 159.93,278.03 159.91,277.97 159.91,277.91 159.91,277.88 157.23,277.88 157.23,278.51 157.35,278.64 160.91,278.64
NET_4_I18_1 on L6_IS3 (solid shape): outline of 739 points within 145.41,250.19 161.92,278.77
NET_4_I48_1 on TOP (solid shape): 169.93,245.24 169.93,244.47 169.67,244.22 169.16,244.22 168.28,243.33 168.28,241.3 167.64,240.66 151.13,240.66 143.89,233.43 138.43,233.43 134.62,237.24 134.62,242.57 137.79,245.75 153.03,245.75 154.31,247.01 168.15,247.01
NET_14_I103_D1A on BOTTOM (solid shape): 291.53,124.97 291.78,124.71 292.74,124.71 293.62,123.82 296.86,123.82 297.88,122.81 297.88,112.33 297.56,112.01 293.5,112.01 293.12,112.39 293.12,118.24 293.37,118.49 293.37,122.17 292.74,122.81 290.58,122.81 290.26,123.13 290.26,123.76 289.94,124.08 288.93,124.08 288.93,125.73 290.45,127.25 291.53,127.25
XCVR_RX_N0C on TOP (solid shape): 330.28,51.76 328.51,51.76 326.74,51.91 326.74,52.26 328.51,52.4 330.28,52.4
XCVR_RX_N0C on TOP (solid shape): 324.88,52.26 324.88,51.9 324,51.72 323.31,51.72 323.22,51.82 323.22,52.32 323.32,52.43 324,52.43
XCVR_RX_N1C on TOP (solid shape): 330.28,97.51 328.5,97.51 326.73,97.65 326.73,98 328.5,98.15 330.28,98.15
XCVR_RX_N1C on TOP (solid shape): 324.85,98.01 324.85,97.65 323.97,97.47 323.27,97.47 323.17,97.57 323.17,98.08 323.27,98.18 323.97,98.18
XCVR_RX_N2C on TOP (solid shape): 275.83,246.9 275.92,246.77 275.95,246.62 275.95,244.26 276.42,242.76 276.43,242.67 276.44,242.63 276.44,242.56 275.94,242.56 275.94,242.27 275.22,242.27 275.22,242.57 274.74,242.57 274.74,242.67 274.76,242.77 274.86,243.14 274.99,243.5 275.23,244.25 275.23,244.26 275.23,246.48 274.6,247.12 274.6,247.14 275.08,247.62 275.11,247.62
XCVR_RX_N3C on TOP (solid shape): 263.03,247.12 263.04,247.12 263.19,246.89 263.25,246.61 263.25,244.26 263.72,242.76 263.73,242.67 263.74,242.63 263.74,242.56 263.24,242.56 263.24,242.27 262.52,242.27 262.52,242.57 262.04,242.57 262.04,242.67 262.06,242.77 262.16,243.14 262.29,243.5 262.53,244.25 262.53,246.62 262.38,247.76 262.39,247.76
XCVR_RX_N<1> on TOP (solid shape): 322.61,98.01 322.61,97.63 322.45,97.47 321.92,97.47 321.91,97.47 321.76,97.47 321.15,97.65 321.15,98 321.75,98.18 321.76,98.18 322.44,98.18
XCVR_RX_N<16> on TOP (solid shape): 312.34,249.81 312.34,249.3 312.17,249.2 311.44,249.2 310.77,249.19 310.6,249.26 310.53,249.43 310.57,249.57 310.69,249.66 311.43,249.91 312.17,249.91
XCVR_RX_N<17> on TOP (solid shape): 312.34,232.66 312.34,232.16 312.17,232.05 311.44,232.05 310.77,232.04 310.6,232.11 310.53,232.28 310.57,232.42 310.69,232.51 311.43,232.77 312.17,232.77
XCVR_RX_N<18> on TOP (solid shape): 312.34,266.95 312.34,266.45 312.17,266.34 311.44,266.34 310.77,266.33 310.6,266.4 310.53,266.57 310.57,266.71 310.69,266.8 311.43,267.06 312.17,267.06
XCVR_RX_N<19> on TOP (solid shape): 312.34,284.1 312.34,283.59 312.17,283.49 311.44,283.49 310.77,283.48 310.6,283.55 310.53,283.72 310.57,283.86 310.69,283.95 311.43,284.2 312.17,284.2
XCVR_RX_P0C on TOP (solid shape): 330.28,67 328.5,67 326.73,67.15 326.73,67.5 328.5,67.64 330.28,67.64
XCVR_RX_P0C on TOP (solid shape): 324.94,67.5 324.94,67.15 324.07,66.96 323.43,66.96 323.22,67.18 323.22,67.46 323.43,67.68 324.07,67.68
XCVR_RX_P1C on TOP (solid shape): 330.28,82.27 328.5,82.27 326.73,82.41 326.73,82.76 328.5,82.91 330.28,82.91
XCVR_RX_P1C on TOP (solid shape): 324.8,82.77 324.8,82.41 323.93,82.23 323.28,82.23 323.09,82.42 323.09,82.75 323.28,82.94 323.93,82.94
XCVR_RX_P2C on TOP (solid shape): 275.96,255.27 276.44,255.27 276.44,255.17 276.42,255.07 276.32,254.7 276.19,254.34 275.95,253.58 275.95,253.58 275.95,251.52 275.89,251.26 275.74,251.03 274.96,250.25 274.96,250.25 274.49,250.72 274.49,250.78 275.23,251.53 275.23,253.58 274.76,255.08 274.75,255.16 274.74,255.21 274.74,255.28 275.24,255.28 275.24,255.56 275.96,255.56
XCVR_RX_P3C on TOP (solid shape): 263.26,255.27 263.74,255.27 263.74,255.17 263.72,255.07 263.62,254.7 263.49,254.34 263.25,253.58 263.25,251.47 263.19,251.21 263.04,250.98 262.26,250.2 261.76,250.7 262.53,251.48 262.53,253.58 262.06,255.08 262.05,255.16 262.04,255.21 262.04,255.28 262.54,255.28 262.54,255.56 263.26,255.56
XCVR_RX_P<0> on TOP (solid shape): 322.71,67.44 322.71,67.18 322.49,66.96 322.01,66.96 321.85,66.96 321.24,67.14 321.24,67.5 321.85,67.67 321.85,67.68 322.47,67.68
XCVR_RX_P<1> on TOP (solid shape): 322.58,82.8 322.58,82.42 322.39,82.23 321.87,82.23 321.87,82.23 321.71,82.23 321.1,82.41 321.1,82.76 321.7,82.94 321.71,82.94 322.44,82.94
XCVR_RX_P<2> on TOP (solid shape): 274.45,250.19 274.45,249.94 274.41,249.9 274.51,249.8 274.08,249.37 274.08,249.36 273.97,249.29 273.84,249.26 273.07,249.27 272.9,249.33 272.83,249.5 272.83,249.52 272.88,249.66 273.01,249.74 273.57,249.86 273.94,250.24 273.94,250.24 274.01,250.31 274.1,250.22 274.32,250.32
XCVR_RX_P<3> on TOP (solid shape): 261.99,249.93 261.35,249.29 261.35,249.28 261.24,249.21 261.11,249.18 260.34,249.19 260.18,249.26 260.11,249.42 260.11,249.44 260.15,249.58 260.28,249.66 260.84,249.79 261.21,250.16 261.21,250.16 261.49,250.43
XCVR_RX_P<16> on TOP (solid shape): 310.8,248.78 311.44,248.64 312.17,248.64 312.34,248.54 312.34,248.03 312.17,247.93 311.44,247.93 310.65,248.33 310.59,248.37 310.54,248.45 310.53,248.54 310.6,248.71 310.77,248.78
XCVR_RX_P<17> on TOP (solid shape): 310.8,231.63 311.44,231.5 312.17,231.5 312.34,231.39 312.34,230.89 312.17,230.78 311.44,230.78 310.65,231.19 310.59,231.23 310.54,231.31 310.53,231.39 310.6,231.56 310.77,231.64
XCVR_RX_P<18> on TOP (solid shape): 310.8,265.92 311.44,265.79 312.17,265.79 312.34,265.68 312.34,265.18 312.17,265.07 311.44,265.07 310.65,265.48 310.59,265.52 310.54,265.6 310.53,265.68 310.6,265.85 310.77,265.93
XCVR_RX_P<19> on TOP (solid shape): 310.8,283.07 311.44,282.93 312.17,282.93 312.34,282.83 312.34,282.32 312.17,282.22 311.44,282.22 310.65,282.62 310.59,282.66 310.54,282.74 310.53,282.83 310.6,283 310.77,283.07
XCVR_TX_N<0> on TOP (solid shape): 330.28,112.75 328.5,112.75 326.73,112.89 326.73,113.24 328.5,113.39 330.28,113.39
XCVR_TX_N<1> on TOP (solid shape): 330.28,21.17 328.51,21.17 326.74,21.32 326.74,21.67 328.51,21.81 330.28,21.81
XCVR_TX_N<2> on TOP (solid shape): 289.12,242.76 289.13,242.67 289.14,242.63 289.14,242.56 288.64,242.56 288.64,242.27 287.92,242.27 287.92,242.57 287.44,242.57 287.44,242.67 287.46,242.77 287.56,243.14 287.69,243.5 287.93,244.25 287.93,244.26 288.65,244.26
XCVR_TX_N<3> on TOP (solid shape): 251.02,242.76 251.03,242.67 251.04,242.63 251.04,242.56 250.54,242.56 250.54,242.27 249.82,242.27 249.82,242.57 249.34,242.57 249.34,242.67 249.36,242.77 249.46,243.14 249.59,243.5 249.83,244.25 249.83,244.26 250.55,244.26
XCVR_TX_P<0> on TOP (solid shape): 330.28,127.99 328.5,127.99 326.73,128.13 326.73,128.48 328.5,128.63 330.28,128.63
XCVR_TX_P<1> on TOP (solid shape): 330.28,36.42 328.5,36.42 326.73,36.56 326.73,36.91 328.5,37.06 330.28,37.06
XCVR_TX_P<2> on TOP (solid shape): 288.66,255.27 289.14,255.27 289.14,255.17 289.12,255.07 289.02,254.7 288.89,254.34 288.65,253.58 288.65,253.58 287.93,253.58 287.46,255.08 287.45,255.16 287.44,255.21 287.44,255.28 287.94,255.28 287.94,255.56 288.66,255.56
XCVR_TX_P<3> on TOP (solid shape): 250.56,255.27 251.04,255.27 251.04,255.17 251.02,255.07 250.92,254.7 250.79,254.34 250.55,253.58 250.55,253.58 249.83,253.58 249.36,255.08 249.35,255.16 249.34,255.21 249.34,255.28 249.84,255.28 249.84,255.56 250.56,255.56
N24962500 on TOP (solid shape): 50.29,259.46 50.29,256.54 50.1,256.35 45.4,256.35 45.21,256.54 45.21,259.33 45.4,259.52 50.23,259.52

Small or netless copper shapes (teardrops, artwork): 23 on TOP

## Text on the board
BOTTOM: COPYRIGHT   2003 | 100-0365000-01 REV.C | 18
Ref Des/Silkscreen Bottom: 9 | 6 | 5 | 1 | 3.3V PMC INTERFACE
User.Comments: REV. | FIGURE | 86.0 | 90.0 | 94.0 | SIZE | 62.0 | 67.0 | 55.0 | 118.0 | 126.0 | 138.0 | 47.0 | 36.0 | 42.0 | 49.0 | 52.0 | 170.0 | 32.0 | 10.0 | 56.0 | 120.0 | 125.0 | 128.0 | 24.0 | 28.0 | 85.0 | 21.0 | 2.0 | TOLERANCE | 3.0 | DRILL CHART (ALL UNITS ARE IN INCHES) | NON-PLATED | PLATED | 8 | 2 | 5 | QTY | 10 | 4 | 54 | 339 | 18 | 19 | 6112 | 212 | 28 | 249 | 11 | 6 | 362 | 256 | C
TOP: 1
Ref Des/Assembly Top: U53 | PRIMARY SIDE | SECONDARY SIDE
L2_GND1: 2
L3_IS1: 3
L4_IS2: 4
L5_PWR1: 5
L6_IS3: 6
L7_IS4: 7
L8_GND2: 8
L9_IS5: 9
L10_IS6: 10
L11_PWR2: 11
L12_IS7: 12
L13_IS8: 13
L14_GND3: 14
L15_IS9: 15
L16_IS10: 16
L17_PWR3: 17
DIMENSION: (2pl) | .250
User.11: 28. DELIVERY, PROVIDE 6 BOARDS TO ALTERA AND 2 BOARDS TO FLEXTRONICS FOR SMT AND | OF 100 MILS FROM ANY OTHER COPPER FEATURE ON THE BOARD. | THERMAL TESTING. | 26. COPPER THIEVING SHALL BE APPLIED WHEREVER REQUIRED BUT MUST HAVE A SPACING | 27. REMOVE ALL UNCONNECTED VIA PADS IN INNER LAYERS. | 22. VENDOR TO PROVIDE 2 SOLDER SAMPLES WITH FIRST SHIPMENT. | 23. DETAILS NOT SPECIFIED ARE AT MANUFACTURER'S OPTION, HOWEVER | FINAL APPROVAL MUST BE OBTAINED. | 24  THESE HOLES MAY BE PLATED SHUT OR SOLDER FILLED. | 25. PLUG VIA HOLES FROM         SIDE WITH SR-1000 OR EQUIVALENT MATERIAL, CLEAR | UV MASK IS ACCEPTABLE. PLUG HEIGHT NOT TO EXCEED 0.003 OVER FINISHED PLATING HEIGHT. | 21. VENDOR TO PROVIDE                     ONE CROSS SECTION PER LOT WITH SHIPMENT. | INCHES MINIMUM ELECTROLESS NICKEL (Ni) FOLLOWED BY 3-8 MICRO INCHES | IMMERSION GOLD (Au). | 17  FINISH IS SOLDER MASK OVER BARE COPPER (SMOBC) BOTH SIDES WITH 150 MICRO | 18  SILKSCREEN USING WHITE NONCONDUCTIVE INK. NO INK TO APPEAR ON EXPOSED | COPPER SUCH AS PLATED THROUGH HOLE PADS AND SURFACE MOUNT LANDS. INK | ON SOLDER MASK COVERED PADS IS PERMISSIBLE. CLIPPING OF SILKSCREEN | 0.008 MAX. FROM PADS IS PERMITTED IF REQUIRED. | 19. 100% CONTINUITY AND ISOLATION ELECTRICAL TESTING PER CURRENT IPC TEST METHODS | REQUIRED FOR EVERY PCB. FINAL PCB TEST DATA MUST BE CROSS-REFERENCED TO | IPC-D-356 FILE, NEUTRAL FILE OR NETLIST PROVIDED. | 20  CONTROLLED IMPEDANCE LINES ARE AS FOLLOWS: | NOTES UNLESS OTHERWISE SPECIFIED: | 1. ALTERA PCB PART NUMBER: P/N 100-0365000-01 REV.C | 2. THIS DRAWING IS VIEWED FROM THE PRIMARY OR TOP SIDE OF PCB. | 3  FABRICATION OF THIS PCB SHALL BE IN CONFORMANCE WITH THE FOLLOWING SPECIFICATIONS: | 4. FABRICATION OF THIS PCB TO BE ACCEPTABLE TO IPC-A-600 CLASS 2(LATEST REVISION). | 5. ALL DIMENSIONAL LIMITS APPLY AFTER PLATING OR PROCESSING. | 6. TOLERANCES OF DATUM HOLE TO:  BOARD EDGE LOCATIONS +/- 0.010. | DRILLED HOLE LOCATIONS +/- 0.003. | V-SCORE LOCATIONS +/- 0.010 (IF APPLICABLE). | 7  BASE MATERIAL:                , MIN. Tg OF     DEGREES C. | 8. FLAME CLASS: UL 94V-0 & MUST MEET REQUIREMENTS OF UL796. | 9. MANUFACTURER MUST BE UL RECOGNIZED TO PRODUCE THIS PRODUCT SUCH THAT | IT MEETS 170 DEGREES CELSIUS MAXIMUM OPERATING TEMPERATURE (MOT). | 10  THE FOLLOWING MUST BE MARKED OR ETCHED ON SECONDARY SIDE OF PCB IN AREA SHOWN: | DATE CODE. | UL RECOGNIZED VENDOR ID, UL TYPE DESIGNATION AND/OR MARKINGS WHICH REFLECT | THE SPECIFIED FLAME CLASS AND MAXIMUM OPERATING TEMPERATURE RATINGS. | 11. BOW & TWIST SHALL BE DETERMINED BY PHYSICAL MEASUREMENT AND PERCENTAGE CALCULATION | IN ACCORDANCE WITH IPC-TM-650, METHOD 2.4.22. BOW AND TWIST MAY NOT EXCEED 0.7%. | 12. HOLE/SLOT PLATING = 0.001 MIN. AVERAGE / 0.0008 ABSOLUTE MIN. PLATING. | HOLE/SLOT DIAMETERS ARE SPECIFIED AFTER PLATING (SEE HOLE SCHEDULE). | 13. SMEAR REMOVAL SHALL NOT ETCHBACK GREATER THAN 0.001. | 14. INTERNAL ANNULAR RING 0.001 MINIMUM. EXTERNAL ANNULAR RING 0.002 MINIMUM. BOTH | ARE MEASURED AT LINE TO PAD ENTRY. NON-FUNCTIONAL INNER LAYER PADS MAY BE REMOVED. | SNOWMAN/TEAR DROPPING OF TRACE TO PAD JUNCTION IS PERMITTED PROVIDED MINIMUM | METAL-TO-METAL ARTWORK SPACINGS ARE NOT COMPROMISED. | 15. FINISHED CONDUCTOR WIDTH NOT TO BE REDUCED MORE THAN 20% OF MINIMUM WIDTH FROM | ARTWORK SUPPLIED. FINISHED CONDUCTOR SPACING NOT TO BE REDUCED MORE THAN 20% OF | MINIMUM SPACING FROM ARTWORK SUPPLIED. | 16  SOLDER MASK IS LIQUID PHOTO IMAGEABLE WITH GLOSSY FINISH AND COLORED GREEN | ACCORDANCE WITH IPC-SM-840C CLASS T. REGISTRATION TO BE WITHIN +/-0.003 OF ITS | RESPECTIVE OUTER CIRCUIT LAYERS. VENDOR MAY ADJUST SOLDERMASK WHEREVER SOLDERMASK | PAD ARE THE SAME SIZE (1:1) TO PROVIDE UP TO .003" MAXIMUM CLEARANCE FROM MASK TO | PAD PROVIDED NO ADJACENT COPPER IS EXPOSED AND NO CONFLICT IS PRODUCED WITH ANY | STATED "VIA TENTING/PLUGGING" REQUIREMENTS (IF APPLICABLE). | NOTE THAT THERE ARE AREAS ON PRIMARY SIDE THAT ARE CLEAR OF SOLDERMASK. | SECONDARY SIDE WILL REQUIRED VIAS TO BE EXPOSED. | IN | 10 | 20 | 24 | 16 | 7 | 3 | 18 | 17 | DETAIL | SCALE: NONE | (CROSS SECTION) | A
User.41: J. MANNING
User.43: 9330 Scranton Road | Suite 400 | San Diego, CA | 92121 | NOTES: UNLESS OTHERWISE SPECIFIED | 1. | 2. | 3. | 4. | ASSEMBLE BOARD PER IPC-A-610(LATEST REVISION) STANDARD | HANDLE MOISTURE SENSITIVE DEVICES(MSD) PER MANUFACTURE'S | CALL OUT ON MSD LABEL. IF MSD LABEL IS MISSING OR NOT LEGIBLE | THEN ALL PLASTIC PACKAGED COMPONENTS ARE TO BE CONSIDERED MSD | LEVEL 6 AND USE EIA/JEP 113-A FOR HANDLING. | REWORK MUST BE APPROVED BY CUSTOMER BEFORE BEING ACCEPTIBLE. | USE IPC-R-700(LATEST REVISION) FOR ALL PCBA REWORK APPROVED. | SQUARE PIN PADS DENOTE PIN 1 OF ICs/CONNECTORS, POSITIVE END | FOR CAPACITORS OR CATHODE END FOR DIODES. | 130-0365000-01 | Altera Corporation
User.45: ETHERNET | 10/100 | GND | POWER | ATX | TEL_ON | GND_PLL | ATX_ON | STRATIX_PB_[0:3] | 3.3V_LIN_EN | GX_CLR | STRATIX_GX_PB_[0:3] | S_CLR | SANTA CRUZ INTERFACE | STRATIX | GX_LED | GP FLASH | STRATIX_LED | 1.5V_GX_INT | MICTOR | 3.3V_GX_IO | 3.3V_S_IO | RMT | JTAG | CONFIG SCHEME | PS HDR | STD | 3.3V | CLKS_SOURCE | 3.3V_XCVR | GND_RTN | -48V_IN | PGM[2:0] | CLK_OUTA | STRATIX GX USER[7:0] | STRATIX USER[7:0] | GND_HSSI | STRATIX GX | CLK_OUTB | EXT_CLK_IN_P | CLK_DIV_A | 1.25V VREF | RU/LU | EXT_CLK_IN_N | 1.25V | DIV_20_LVPECL | CLK_DIV_B | OUT_P | OUT_N | CLK_IN_N | DISPLAY | DIV_20_LVTTL_OUT | CLK_IN_P | EXT CLK1 | XCVR HMZD INTERFACE | EXT CLK2 | TRIG_155_52 | TRIG_156_25 | OSC | SMA | 156.25MHZ | SELECT | CLOCK | 155.52MHZ | 33MHZ SMA | INPUT | INPUT2_GX_N | INPUT2_GX_P | XTAL3_OUT_TP1 | SPI-4.2 HEADERS | HSSI | 15P | 14P | 15N | 14N | XPAK | P  N | INPUT4_GX | RECOV | REFCLKB | CLK2 | INPUT1_GX_N | INPUT1_GX_P | 1.5V_PLL | TX_N3 | TX_P3 | CLK3 | RX_N3 | RX_P3 | CLK1 | MDIO HDR | + | 1.5V_XCVR | STRATIX GX MICTOR | INTERFACE | SFP | RX_N2 | RX_P2 | CLK0 | CLK_OUT_N | CLK_OUT_P | TX_N0 | TX_P0 | TX_N1 | TX_P1 | XCVR7 | XCVR5 | XCVR4 | XCVR6 | DPA | TX_P2 | TX_N2 | CLK4 | CONNECTORS | INPUT3_GX_P | RX_P0 | RX_N0 | RX_N1 | RX_P1 | HSSDC2 | XCVR19 | XCVR16 | XCVR17 | XCVR18 | INPUT3_GX_N | NO | YES | PS_HDR | EPC16 | STRATIX GX RS232 | (BOTTOM) | STRATIX RS232 | STRATIX BYPASS | STRATIX GX BYPASS | (TOP) | OFF | GX CLR | RESET | S_CONF_DONE | GX_CONF_DONE | 1.5V_S_INT | 2.5V_GX_IO | DATA | GEN | 2.5V | STRATIX TEST HDR | DDR DIMM | BRIDGE HEADERS | STRATIX GX TEST HDR | 130-0365000-01 | MADE IN USA | L01/TOP - .5 Oz Cu BEFORE PLATING | L02/PLN - 1 Oz Cu | L03/SIG - .5 Oz Cu | L04/SIG - .5 Oz Cu | L05/PLN - 1 Oz Cu | L06/SIG - .5 Oz Cu | L07/SIG - .5 Oz Cu | L08/PLN - 1 Oz Cu | L09/SIG - .5 Oz Cu | L010/SIG - .5 Oz Cu | L011/PLN - 1 Oz Cu | L012/SIG - .5 Oz Cu | L013/SIG - .5 Oz Cu | L014/PLN - 1 Oz Cu | L015/SIG - .5 Oz Cu | L016/SIG - .5 Oz Cu | L017/PLN - 1 Oz Cu | L018/BOT - .5 Oz Cu BEFORE PLATING | PREPREG - 3.6 MILS THK | CORE    - 4 MILS THK | PREPREG - 6.1 MILS THK | PREPREG - 4.5 MILS THK | CORE    - 5 MILS THK | 0.7 MILS THK | 1.4 MILS THK | H) CONTINUED.... | L12 | L13 | L14 | L15 | L16 | L17 | L18 | ONE TEST COUPON AND | 3.7 | PRIMARY | 4 | 5.5 | 5.3 | BOARD LAYER 16 OF 18, INNER SIGNAL-10 | BOARD LAYER 13 OF 18, INNER SIGNAL-8 | BOARD LAYER 12 OF 18, INNER SIGNAL-7 | BOARD LAYER 11 OF 18, POWER PLANE-2 | BOARD LAYER 2 OF 18, GND PLANE-1 | BOARD LAYER 14 OF 18, GND PLANE-3 | BOARD LAYER 5 OF 18, PWR PLANE-1 | FILM SHEET 14 OF 25 | BOARD LAYER 17 OF 18, POWER PLANE-3 | BOARD LAYER 15 OF 18, INNER SIGNAL-9 | FILM SHEET 13 OF 25 | BOARD LAYER 8 OF 18, GND PLANE-2 | FILM SHEET 17 OF 25 | FILM SHEET 12 OF 25 | FILM SHEET 16 OF 25 | FILM SHEET 11 OF 25 | FILM SHEET 5 OF 25 | FILM SHEET 2 OF 25 | FILM SHEET 8 OF 25 | FILM SHEET 15 OF 25 | H) L3,L4,L6,L7,L9,L10,L12,L13,L16; TIGHTLY EDGE-COUPLED MICROSTRIP | DESIRED IMEPDANCE: 100 OHMS DIFFERENTIAL. USE DIMENSIONS PROVIDED | BY TITAN. BOARD IS ROUTED WITH 5 MIL LINES WITH 5 MIL SPACING. | L10 | L11 | L3 | L4 | L5 | L6 | L7 | L8 | L9 | L1 | L2 | F) L1 HIGH SPEED LINES, DESIRED IMPEDANCE: 100 OHMS DIFFERENTIAL | G) L13 AND L15, EDGE-COUPLED STRIPLINE, DESIRED IMPEDANCE: 100 OHMS | (SHOULD NOT HAVE SOLDERMASK) | DIFFERENTIAL. | SIGNAL | 6 | 4.95 | 5 | 14 | 15.05 | 15 | IPC-6011 CLASS 2 (GENERIC). | a) TOLERANCE (ALL LINES) +/- 5%, | B) L1 HIGH SPEED LINES AT EDGE LAUNCH SMA PINS, DESIRED IMPEDANCE: 50 OHMS | C) L1 HIGH SPEED LINES AT CAPACITOR PAD (0402 SIZE COMPONENT) AFTER EDGE | D) L1 HIGH SPEED LINES AT UPRIGHT SMA PIN, DESIRED IMPEDANCE: 50 OHMS | E) L1 HIGH SPEED LINES AT 0402 CAP PAD, DESIRED IMPEDANCE: 50 OHMS | (NO SOLDERMASK). | LAUNCH SMA. DESIRED IMPEDANCE: 50 OHMS (NO SOLDERMASK) | (NO SOLDERMASK) | NOTE: THERE IS A GRADUAL TRANSISTION FROM CONFIGURATION B TO C. | NOTE: THERE IS A GRADUAL TRANSISTION FROM CONFIGURATION D TO E. | FR4 GLASS EPOXY | 20 | 28 | 67 | 170 | A | (TITAN DIMENSIONS) | DEVELOPMENT | BOARD | .093 | +/-.005
