# Allegro board pre_route.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CFCONN50P
  rect 2.489x5.994 smd: (-22.86,-12.532) (22.86,-12.532)
  round 0.127 hole 1.194 unplated: (-21.828,5.593) (21.828,5.593)
  round 0.127 hole 2.286 unplated: (-20.491,3.216) (20.491,3.216)
  rect 0.432x1.981 smd: 1(-15.557,5.791) 2(-14.287,5.791) 3(-13.018,5.791) 4(-11.748,5.791) 5(-10.477,5.791) 6(-9.207,5.791) 7(-7.938,5.791) 8(-6.668,5.791) 9(-5.397,5.791) 10(-4.128,5.791) 11(-2.857,5.791) 12(-1.587,5.791) 13(-0.318,5.791) 14(0.953,5.791) 15(2.223,5.791) 16(3.493,5.791) 17(4.763,5.791) 18(6.032,5.791) 19(7.303,5.791) 20(8.572,5.791) 21(9.842,5.791) 22(11.113,5.791) 23(12.383,5.791) 24(13.652,5.791) 25(14.922,5.791) 26(-14.922,5.791) 27(-13.652,5.791) 28(-12.383,5.791) 29(-11.113,5.791) 30(-9.842,5.791) 31(-8.572,5.791) 32(-7.303,5.791) 33(-6.032,5.791) 34(-4.763,5.791) 35(-3.493,5.791) 36(-2.223,5.791) 37(-0.953,5.791) 38(0.318,5.791) 39(1.587,5.791) 40(2.857,5.791) 41(4.128,5.791) 42(5.397,5.791) 43(6.668,5.791) 44(7.938,5.791) 45(9.207,5.791) 46(10.477,5.791) 47(11.748,5.791) 48(13.018,5.791) 49(14.287,5.791) 50(15.557,5.791)
CON120_HM-ZD
  rect 1.118x1.118 hole 0.61: 1A(0,0)
  round 1.118 hole 0.61: 1B(0,1.5) 1BG(0,3) 1C(0,4.5) 1D(0,6) 1DG(0,7.5) 1E(0,9) 1F(0,10.5) 1FG(0,12) 1G(0,13.5) 1H(0,15) 1HG(0,16.5) 2A(-2.5,0) 2B(-2.5,1.5) 2BG(-2.5,3) 2C(-2.5,4.5) 2D(-2.5,6) 2DG(-2.5,7.5) 2E(-2.5,9) 2F(-2.5,10.5) 2FG(-2.5,12) 2G(-2.5,13.5) 2H(-2.5,15) 2HG(-2.5,16.5) 3A(-5,0) 3B(-5,1.5) 3BG(-5,3) 3C(-5,4.5) 3D(-5,6) 3DG(-5,7.5) 3E(-5,9) 3F(-5,10.5) 3FG(-5,12) 3G(-5,13.5) 3H(-5,15) 3HG(-5,16.5) 4A(-7.5,0) 4B(-7.5,1.5) 4BG(-7.5,3) 4C(-7.5,4.5) 4D(-7.5,6) 4DG(-7.5,7.5) 4E(-7.5,9) 4F(-7.5,10.5) 4FG(-7.5,12) 4G(-7.5,13.5) 4H(-7.5,15) 4HG(-7.5,16.5) 5A(-10,0) 5B(-10,1.5) 5BG(-10,3) 5C(-10,4.5) 5D(-10,6) 5DG(-10,7.5) 5E(-10,9) 5F(-10,10.5) 5FG(-10,12) 5G(-10,13.5) 5H(-10,15) 5HG(-10,16.5) 6A(-12.5,0) 6B(-12.5,1.5) 6BG(-12.5,3) 6C(-12.5,4.5) 6D(-12.5,6) 6DG(-12.5,7.5) 6E(-12.5,9) 6F(-12.5,10.5) 6FG(-12.5,12) 6G(-12.5,13.5) 6H(-12.5,15) 6HG(-12.5,16.5) 7A(-15,0) 7B(-15,1.5) 7BG(-15,3) 7C(-15,4.5) 7D(-15,6) 7DG(-15,7.5) 7E(-15,9) 7F(-15,10.5) 7FG(-15,12) 7G(-15,13.5) 7H(-15,15) 7HG(-15,16.5) 8A(-17.5,0) 8B(-17.5,1.5) 8BG(-17.5,3) 8C(-17.5,4.5) 8D(-17.5,6) 8DG(-17.5,7.5) 8E(-17.5,9) 8F(-17.5,10.5) 8FG(-17.5,12) 8G(-17.5,13.5) 8H(-17.5,15) 8HG(-17.5,16.5) 9A(-20,0) 9B(-20,1.5) 9BG(-20,3) 9C(-20,4.5) 9D(-20,6) 9DG(-20,7.5) 9E(-20,9) 9F(-20,10.5) 9FG(-20,12) 9G(-20,13.5) 9H(-20,15) 9HG(-20,16.5) 10A(-22.5,0) 10B(-22.5,1.5) 10BG(-22.5,3) 10C(-22.5,4.5) 10D(-22.5,6) 10DG(-22.5,7.5) 10E(-22.5,9) 10F(-22.5,10.5) 10FG(-22.5,12) 10G(-22.5,13.5) 10H(-22.5,15) 10HG(-22.5,16.5)
DB9DOUBLE
  rect 1.905x1.905 hole 1.245: 1(-0.051,0) 10(-0.051,6.604)
  round 1.905 hole 1.245: 2(2.718,0) 3(5.486,0) 4(8.255,0) 5(11.024,0) 6(1.333,2.845) 7(4.102,2.845) 8(6.871,2.845) 9(9.639,2.845) 11(2.718,6.604) 12(5.486,6.604) 13(8.255,6.604) 14(11.024,6.604) 15(1.333,9.449) 16(4.102,9.449) 17(6.871,9.449) 18(9.639,9.449)
  round 7.62 hole 3.048: 19(-7.01,1.422) 20(17.983,1.422) 21(-7.01,9.423) 22(17.983,9.423)
DIMM240
  round 3.81 hole 2.438: (-73,0) (0,0) (65,0)
  rect 1.27x1.27 hole 0.711: 1(-65.5,-0.95)
  round 1.27 hole 0.711: 2(-64.5,-2.85) 3(-63.5,-0.95) 4(-62.5,-2.85) 5(-61.5,-0.95) 6(-60.5,-2.85) 7(-59.5,-0.95) 8(-58.5,-2.85) 9(-57.5,-0.95) 10(-56.5,-2.85) 11(-55.5,-0.95) 12(-54.5,-2.85) 13(-53.5,-0.95) 14(-52.5,-2.85) 15(-51.5,-0.95) 16(-50.5,-2.85) 17(-49.5,-0.95) 18(-48.5,-2.85) 19(-47.5,-0.95) 20(-46.5,-2.85) 21(-45.5,-0.95) 22(-44.5,-2.85) 23(-43.5,-0.95) 24(-42.5,-2.85) 25(-41.5,-0.95) 26(-40.5,-2.85) 27(-39.5,-0.95) 28(-38.5,-2.85) 29(-37.5,-0.95) 30(-36.5,-2.85) 31(-35.5,-0.95) 32(-34.5,-2.85) 33(-33.5,-0.95) 34(-32.5,-2.85) 35(-31.5,-0.95) 36(-30.5,-2.85) 37(-29.5,-0.95) 38(-28.5,-2.85) 39(-27.5,-0.95) 40(-26.5,-2.85) 41(-25.5,-0.95) 42(-24.5,-2.85) 43(-23.5,-0.95) 44(-22.5,-2.85) 45(-21.5,-0.95) 46(-20.5,-2.85) 47(-19.5,-0.95) 48(-18.5,-2.85) 49(-17.5,-0.95) 50(-16.5,-2.85) 51(-15.5,-0.95) 52(-14.5,-2.85) 53(-13.5,-0.95) 54(-12.5,-2.85) 55(-11.5,-0.95) 56(-10.5,-2.85) 57(-9.5,-0.95) 58(-8.5,-2.85) 59(-7.5,-0.95) 60(-6.5,-2.85) 61(-5.5,-0.95) 62(-4.5,-2.85) 63(-3.5,-0.95) 64(-2.5,-2.85) 65(2.5,-0.95) 66(3.5,-2.85) 67(4.5,-0.95) 68(5.5,-2.85) 69(6.5,-0.95) 70(7.5,-2.85) 71(8.5,-0.95) 72(9.5,-2.85) 73(10.5,-0.95) 74(11.5,-2.85) 75(12.5,-0.95) 76(13.5,-2.85) 77(14.5,-0.95) 78(15.5,-2.85) 79(16.5,-0.95) 80(17.5,-2.85) 81(18.5,-0.95) 82(19.5,-2.85) 83(20.5,-0.95) 84(21.5,-2.85) 85(22.5,-0.95) 86(23.5,-2.85) 87(24.5,-0.95) 88(25.5,-2.85) 89(26.5,-0.95) 90(27.5,-2.85) 91(28.5,-0.95) 92(29.5,-2.85) 93(30.5,-0.95) 94(31.5,-2.85) 95(32.5,-0.95) 96(33.5,-2.85) 97(34.5,-0.95) 98(35.5,-2.85) 99(36.5,-0.95) 100(37.5,-2.85) 101(38.5,-0.95) 102(39.5,-2.85) 103(40.5,-0.95) 104(41.5,-2.85) 105(42.5,-0.95) 106(43.5,-2.85) 107(44.5,-0.95) 108(45.5,-2.85) 109(46.5,-0.95) 110(47.5,-2.85) 111(48.5,-0.95) 112(49.5,-2.85) 113(50.5,-0.95) 114(51.5,-2.85) 115(52.5,-0.95) 116(53.5,-2.85) 117(54.5,-0.95) 118(55.5,-2.85) 119(56.5,-0.95) 120(57.5,-2.85) 121(-65.5,2.85) 122(-64.5,0.95) 123(-63.5,2.85) 124(-62.5,0.95) 125(-61.5,2.85) 126(-60.5,0.95) 127(-59.5,2.85) 128(-58.5,0.95) 129(-57.5,2.85) 130(-56.5,0.95) 131(-55.5,2.85) 132(-54.5,0.95) 133(-53.5,2.85) 134(-52.5,0.95) 135(-51.5,2.85) 136(-50.5,0.95) 137(-49.5,2.85) 138(-48.5,0.95) 139(-47.5,2.85) 140(-46.5,0.95) 141(-45.5,2.85) 142(-44.5,0.95) 143(-43.5,2.85) 144(-42.5,0.95) 145(-41.5,2.85) 146(-40.5,0.95) 147(-39.5,2.85) 148(-38.5,0.95) 149(-37.5,2.85) 150(-36.5,0.95) 151(-35.5,2.85) 152(-34.5,0.95) 153(-33.5,2.85) 154(-32.5,0.95) 155(-31.5,2.85) 156(-30.5,0.95) 157(-29.5,2.85) 158(-28.5,0.95) 159(-27.5,2.85) 160(-26.5,0.95) 161(-25.5,2.85) 162(-24.5,0.95) 163(-23.5,2.85) 164(-22.5,0.95) 165(-21.5,2.85) 166(-20.5,0.95) 167(-19.5,2.85) 168(-18.5,0.95) 169(-17.5,2.85) 170(-16.5,0.95) 171(-15.5,2.85) 172(-14.5,0.95) 173(-13.5,2.85) 174(-12.5,0.95) 175(-11.5,2.85) 176(-10.5,0.95) 177(-9.5,2.85) 178(-8.5,0.95) 179(-7.5,2.85) 180(-6.5,0.95) 181(-5.5,2.85) 182(-4.5,0.95) 183(-3.5,2.85) 184(-2.5,0.95) 185(2.5,2.85) 186(3.5,0.95) 187(4.5,2.85) 188(5.5,0.95) 189(6.5,2.85) 190(7.5,0.95) 191(8.5,2.85) 192(9.5,0.95) 193(10.5,2.85) 194(11.5,0.95) 195(12.5,2.85) 196(13.5,0.95) 197(14.5,2.85) 198(15.5,0.95) 199(16.5,2.85) 200(17.5,0.95) 201(18.5,2.85) 202(19.5,0.95) 203(20.5,2.85) 204(21.5,0.95) 205(22.5,2.85) 206(23.5,0.95) 207(24.5,2.85) 208(25.5,0.95) 209(26.5,2.85) 210(27.5,0.95) 211(28.5,2.85) 212(29.5,0.95) 213(30.5,2.85) 214(31.5,0.95) 215(32.5,2.85) 216(33.5,0.95) 217(34.5,2.85) 218(35.5,0.95) 219(36.5,2.85) 220(37.5,0.95) 221(38.5,2.85) 222(39.5,0.95) 223(40.5,2.85) 224(41.5,0.95) 225(42.5,2.85) 226(43.5,0.95) 227(44.5,2.85) 228(45.5,0.95) 229(46.5,2.85) 230(47.5,0.95) 231(48.5,2.85) 232(49.5,0.95) 233(50.5,2.85) 234(51.5,0.95) 235(52.5,2.85) 236(53.5,0.95) 237(54.5,2.85) 238(55.5,0.95) 239(56.5,2.85) 240(57.5,0.95)
DIP8
  rect 1.524x1.524 hole 1.067: 1(0,0)
  round 1.524 hole 1.067: 2(0,-2.54) 3(0,-5.08) 4(0,-7.62) 5(7.62,-7.62) 6(7.62,-5.08) 7(7.62,-2.54) 8(7.62,0)
EDGE_LAUNCHED_SMA
  rect 1.778x0.635 smd: 1(0,0)
  round 2.667 hole 2.159: 2(-1.795,4.755) 3(-1.795,-4.745)
  round 0.914 hole 0.533: 4(0.435,-1.146) 5(0.435,1.146) 6(-0.835,-1.146) 7(-0.835,1.146) 8(-2.545,1.165) 9(-4.035,1.245) 10(0.435,2.515) 11(-1.055,2.515) 12(-2.545,2.515) 13(-4.035,2.515) 14(-4.035,4.005) 15(0.435,4.005) 16(-4.035,5.495) 17(0.435,5.495) 18(-4.035,6.985) 19(-2.545,6.985) 20(-1.055,6.985) 21(0.435,6.985) 22(-4.035,-1.245) 23(-2.545,-1.165) 24(-4.035,-2.515) 25(-2.545,-2.515) 26(-1.055,-2.515) 27(0.435,-2.515) 28(-4.035,-4.005) 29(0.435,-4.005) 30(-4.035,-5.495) 31(0.435,-5.495) 32(-4.035,-6.985) 33(-2.545,-6.985) 34(-1.055,-6.985) 35(0.435,-6.985)
F1020
  round 0.457 smd: A2(-14.5,15.5) A3(-13.5,15.5) A4(-12.5,15.5) A5(-11.5,15.5) A6(-10.5,15.5) A7(-9.5,15.5) A8(-8.5,15.5) A9(-7.5,15.5) A10(-6.5,15.5) A11(-5.5,15.5) A12(-4.5,15.5) A13(-3.5,15.5) A14(-2.5,15.5) A15(-1.5,15.5) A16(-0.5,15.5) A17(0.5,15.5) A18(1.5,15.5) A19(2.5,15.5) A20(3.5,15.5) A21(4.5,15.5) A22(5.5,15.5) A23(6.5,15.5) A24(7.5,15.5) A25(8.5,15.5) A26(9.5,15.5) A27(10.5,15.5) A28(11.5,15.5) A29(12.5,15.5) A30(13.5,15.5) A31(14.5,15.5) AA1(-15.5,-4.5) AA2(-14.5,-4.5) AA3(-13.5,-4.5) AA4(-12.5,-4.5) AA5(-11.5,-4.5) AA6(-10.5,-4.5) AA7(-9.5,-4.5) AA8(-8.5,-4.5) AA9(-7.5,-4.5) AA10(-6.5,-4.5) AA11(-5.5,-4.5) AA12(-4.5,-4.5) AA13(-3.5,-4.5) AA14(-2.5,-4.5) AA15(-1.5,-4.5) AA16(-0.5,-4.5) AA17(0.5,-4.5) AA18(1.5,-4.5) AA19(2.5,-4.5) AA20(3.5,-4.5) AA21(4.5,-4.5) AA22(5.5,-4.5) AA23(6.5,-4.5) AA24(7.5,-4.5) AA25(8.5,-4.5) AA26(9.5,-4.5) AA27(10.5,-4.5) AA28(11.5,-4.5) AA29(12.5,-4.5) AA30(13.5,-4.5) AA31(14.5,-4.5) AA32(15.5,-4.5) AB1(-15.5,-5.5) AB2(-14.5,-5.5) AB3(-13.5,-5.5) AB4(-12.5,-5.5) AB5(-11.5,-5.5) AB6(-10.5,-5.5) AB7(-9.5,-5.5) AB8(-8.5,-5.5) AB9(-7.5,-5.5) AB10(-6.5,-5.5) AB11(-5.5,-5.5) AB12(-4.5,-5.5) AB13(-3.5,-5.5) AB14(-2.5,-5.5) AB15(-1.5,-5.5) AB16(-0.5,-5.5) AB17(0.5,-5.5) AB18(1.5,-5.5) AB19(2.5,-5.5) AB20(3.5,-5.5) AB21(4.5,-5.5) AB22(5.5,-5.5) AB23(6.5,-5.5) AB24(7.5,-5.5) AB25(8.5,-5.5) AB26(9.5,-5.5) AB27(10.5,-5.5) AB28(11.5,-5.5) AB29(12.5,-5.5) AB30(13.5,-5.5) AB31(14.5,-5.5) AB32(15.5,-5.5) AC1(-15.5,-6.5) AC2(-14.5,-6.5) AC3(-13.5,-6.5) AC4(-12.5,-6.5) AC5(-11.5,-6.5) AC6(-10.5,-6.5) AC7(-9.5,-6.5) AC8(-8.5,-6.5) AC9(-7.5,-6.5) AC10(-6.5,-6.5) AC11(-5.5,-6.5) AC12(-4.5,-6.5) AC13(-3.5,-6.5) AC14(-2.5,-6.5) AC15(-1.5,-6.5) AC16(-0.5,-6.5) AC17(0.5,-6.5) AC18(1.5,-6.5) AC19(2.5,-6.5) AC20(3.5,-6.5) AC21(4.5,-6.5) AC22(5.5,-6.5) AC23(6.5,-6.5) AC24(7.5,-6.5) AC25(8.5,-6.5) AC26(9.5,-6.5) AC27(10.5,-6.5) AC28(11.5,-6.5) AC29(12.5,-6.5) AC30(13.5,-6.5) AC31(14.5,-6.5) AC32(15.5,-6.5) AD1(-15.5,-7.5) AD2(-14.5,-7.5) AD3(-13.5,-7.5) AD4(-12.5,-7.5) AD5(-11.5,-7.5) AD6(-10.5,-7.5) AD7(-9.5,-7.5) AD8(-8.5,-7.5) AD9(-7.5,-7.5) AD10(-6.5,-7.5) AD11(-5.5,-7.5) AD12(-4.5,-7.5) AD13(-3.5,-7.5) AD14(-2.5,-7.5) AD15(-1.5,-7.5) AD16(-0.5,-7.5) AD17(0.5,-7.5) AD18(1.5,-7.5) AD19(2.5,-7.5) AD20(3.5,-7.5) AD21(4.5,-7.5) AD22(5.5,-7.5) AD23(6.5,-7.5) AD24(7.5,-7.5) AD25(8.5,-7.5) AD26(9.5,-7.5) AD27(10.5,-7.5) AD28(11.5,-7.5) AD29(12.5,-7.5) AD30(13.5,-7.5) AD31(14.5,-7.5) AD32(15.5,-7.5) AE1(-15.5,-8.5) AE2(-14.5,-8.5) AE3(-13.5,-8.5) AE4(-12.5,-8.5) AE5(-11.5,-8.5) AE6(-10.5,-8.5) AE7(-9.5,-8.5) AE8(-8.5,-8.5) AE9(-7.5,-8.5) AE10(-6.5,-8.5) AE11(-5.5,-8.5) AE12(-4.5,-8.5) AE13(-3.5,-8.5) AE14(-2.5,-8.5) AE15(-1.5,-8.5) AE16(-0.5,-8.5) AE17(0.5,-8.5) AE18(1.5,-8.5) AE19(2.5,-8.5) AE20(3.5,-8.5) AE21(4.5,-8.5) AE22(5.5,-8.5) AE23(6.5,-8.5) AE24(7.5,-8.5) AE25(8.5,-8.5) AE26(9.5,-8.5) AE27(10.5,-8.5) AE28(11.5,-8.5) AE29(12.5,-8.5) AE30(13.5,-8.5) AE31(14.5,-8.5) AE32(15.5,-8.5) AF1(-15.5,-9.5) AF2(-14.5,-9.5) AF3(-13.5,-9.5) AF4(-12.5,-9.5) AF5(-11.5,-9.5) AF6(-10.5,-9.5) AF7(-9.5,-9.5) AF8(-8.5,-9.5) AF9(-7.5,-9.5) AF10(-6.5,-9.5) AF11(-5.5,-9.5) AF12(-4.5,-9.5) AF13(-3.5,-9.5) AF14(-2.5,-9.5) AF15(-1.5,-9.5) AF16(-0.5,-9.5) AF17(0.5,-9.5) AF18(1.5,-9.5) AF19(2.5,-9.5) AF20(3.5,-9.5) AF21(4.5,-9.5) AF22(5.5,-9.5) AF23(6.5,-9.5) AF24(7.5,-9.5) AF25(8.5,-9.5) AF26(9.5,-9.5) AF27(10.5,-9.5) AF28(11.5,-9.5) AF29(12.5,-9.5) AF30(13.5,-9.5) AF31(14.5,-9.5) AF32(15.5,-9.5) AG1(-15.5,-10.5) AG2(-14.5,-10.5) AG3(-13.5,-10.5) AG4(-12.5,-10.5) AG5(-11.5,-10.5) AG6(-10.5,-10.5) AG7(-9.5,-10.5) AG8(-8.5,-10.5) AG9(-7.5,-10.5) AG10(-6.5,-10.5) AG11(-5.5,-10.5) AG12(-4.5,-10.5) AG13(-3.5,-10.5) AG14(-2.5,-10.5) AG15(-1.5,-10.5) AG16(-0.5,-10.5) AG17(0.5,-10.5) AG18(1.5,-10.5) AG19(2.5,-10.5) AG20(3.5,-10.5) AG21(4.5,-10.5) AG22(5.5,-10.5) AG23(6.5,-10.5) AG24(7.5,-10.5) AG25(8.5,-10.5) AG26(9.5,-10.5) AG27(10.5,-10.5) AG28(11.5,-10.5) AG29(12.5,-10.5) AG30(13.5,-10.5) AG31(14.5,-10.5) AG32(15.5,-10.5) AH1(-15.5,-11.5) AH2(-14.5,-11.5) AH3(-13.5,-11.5) AH4(-12.5,-11.5) AH5(-11.5,-11.5) AH6(-10.5,-11.5) AH7(-9.5,-11.5) AH8(-8.5,-11.5) AH9(-7.5,-11.5) AH10(-6.5,-11.5) AH11(-5.5,-11.5) AH12(-4.5,-11.5) AH13(-3.5,-11.5) AH14(-2.5,-11.5) AH15(-1.5,-11.5) AH16(-0.5,-11.5) AH17(0.5,-11.5) AH18(1.5,-11.5) AH19(2.5,-11.5) AH20(3.5,-11.5) AH21(4.5,-11.5) AH22(5.5,-11.5) AH23(6.5,-11.5) AH24(7.5,-11.5) AH25(8.5,-11.5) AH26(9.5,-11.5) AH27(10.5,-11.5) AH28(11.5,-11.5) AH29(12.5,-11.5) AH30(13.5,-11.5) AH31(14.5,-11.5) AH32(15.5,-11.5) AJ1(-15.5,-12.5) AJ2(-14.5,-12.5) AJ3(-13.5,-12.5) AJ4(-12.5,-12.5) AJ5(-11.5,-12.5) AJ6(-10.5,-12.5) AJ7(-9.5,-12.5) AJ8(-8.5,-12.5) AJ9(-7.5,-12.5) AJ10(-6.5,-12.5) AJ11(-5.5,-12.5) AJ12(-4.5,-12.5) AJ13(-3.5,-12.5) AJ14(-2.5,-12.5) AJ15(-1.5,-12.5) AJ16(-0.5,-12.5) AJ17(0.5,-12.5) AJ18(1.5,-12.5) AJ19(2.5,-12.5) AJ20(3.5,-12.5) AJ21(4.5,-12.5) AJ22(5.5,-12.5) AJ23(6.5,-12.5) AJ24(7.5,-12.5) AJ25(8.5,-12.5) AJ26(9.5,-12.5) AJ27(10.5,-12.5) AJ28(11.5,-12.5) AJ29(12.5,-12.5) AJ30(13.5,-12.5) AJ31(14.5,-12.5) AJ32(15.5,-12.5) AK1(-15.5,-13.5) AK2(-14.5,-13.5) AK3(-13.5,-13.5) AK4(-12.5,-13.5) AK5(-11.5,-13.5) AK6(-10.5,-13.5) AK7(-9.5,-13.5) AK8(-8.5,-13.5) AK9(-7.5,-13.5) AK10(-6.5,-13.5) AK11(-5.5,-13.5) AK12(-4.5,-13.5) AK13(-3.5,-13.5) AK14(-2.5,-13.5) AK15(-1.5,-13.5) AK16(-0.5,-13.5) AK17(0.5,-13.5) AK18(1.5,-13.5) AK19(2.5,-13.5) AK20(3.5,-13.5) AK21(4.5,-13.5) AK22(5.5,-13.5) AK23(6.5,-13.5) AK24(7.5,-13.5) AK25(8.5,-13.5) AK26(9.5,-13.5) AK27(10.5,-13.5) AK28(11.5,-13.5) AK29(12.5,-13.5) AK30(13.5,-13.5) AK31(14.5,-13.5) AK32(15.5,-13.5) AL1(-15.5,-14.5) AL2(-14.5,-14.5) AL3(-13.5,-14.5) AL4(-12.5,-14.5) AL5(-11.5,-14.5) AL6(-10.5,-14.5) AL7(-9.5,-14.5) AL8(-8.5,-14.5) AL9(-7.5,-14.5) AL10(-6.5,-14.5) AL11(-5.5,-14.5) AL12(-4.5,-14.5) AL13(-3.5,-14.5) AL14(-2.5,-14.5) AL15(-1.5,-14.5) AL16(-0.5,-14.5) AL17(0.5,-14.5) AL18(1.5,-14.5) AL19(2.5,-14.5) AL20(3.5,-14.5) AL21(4.5,-14.5) AL22(5.5,-14.5) AL23(6.5,-14.5) AL24(7.5,-14.5) AL25(8.5,-14.5) AL26(9.5,-14.5) AL27(10.5,-14.5) AL28(11.5,-14.5) AL29(12.5,-14.5) AL30(13.5,-14.5) AL31(14.5,-14.5) AL32(15.5,-14.5) AM2(-14.5,-15.5) AM3(-13.5,-15.5) AM4(-12.5,-15.5) AM5(-11.5,-15.5) AM6(-10.5,-15.5) AM7(-9.5,-15.5) AM8(-8.5,-15.5) AM9(-7.5,-15.5) AM10(-6.5,-15.5) AM11(-5.5,-15.5) AM12(-4.5,-15.5) AM13(-3.5,-15.5) AM14(-2.5,-15.5) AM15(-1.5,-15.5) AM16(-0.5,-15.5) AM17(0.5,-15.5) AM18(1.5,-15.5) AM19(2.5,-15.5) AM20(3.5,-15.5) AM21(4.5,-15.5) AM22(5.5,-15.5) AM23(6.5,-15.5) AM24(7.5,-15.5) AM25(8.5,-15.5) AM26(9.5,-15.5) AM27(10.5,-15.5) AM28(11.5,-15.5) AM29(12.5,-15.5) AM30(13.5,-15.5) AM31(14.5,-15.5) B1(-15.5,14.5) B2(-14.5,14.5) B3(-13.5,14.5) B4(-12.5,14.5) B5(-11.5,14.5) B6(-10.5,14.5) B7(-9.5,14.5) B8(-8.5,14.5) B9(-7.5,14.5) B10(-6.5,14.5) B11(-5.5,14.5) B12(-4.5,14.5) B13(-3.5,14.5) B14(-2.5,14.5) B15(-1.5,14.5) B16(-0.5,14.5) B17(0.5,14.5) B18(1.5,14.5) B19(2.5,14.5) B20(3.5,14.5) B21(4.5,14.5) B22(5.5,14.5) B23(6.5,14.5) B24(7.5,14.5) B25(8.5,14.5) B26(9.5,14.5) B27(10.5,14.5) B28(11.5,14.5) B29(12.5,14.5) B30(13.5,14.5) B31(14.5,14.5) B32(15.5,14.5) C1(-15.5,13.5) C2(-14.5,13.5) C3(-13.5,13.5) C4(-12.5,13.5) C5(-11.5,13.5) C6(-10.5,13.5) C7(-9.5,13.5) C8(-8.5,13.5) C9(-7.5,13.5) C10(-6.5,13.5) C11(-5.5,13.5) C12(-4.5,13.5) C13(-3.5,13.5) C14(-2.5,13.5) C15(-1.5,13.5) C16(-0.5,13.5) C17(0.5,13.5) C18(1.5,13.5) C19(2.5,13.5) C20(3.5,13.5) C21(4.5,13.5) C22(5.5,13.5) C23(6.5,13.5) C24(7.5,13.5) C25(8.5,13.5) C26(9.5,13.5) C27(10.5,13.5) C28(11.5,13.5) C29(12.5,13.5) C30(13.5,13.5) C31(14.5,13.5) C32(15.5,13.5) D1(-15.5,12.5) D2(-14.5,12.5) D3(-13.5,12.5) D4(-12.5,12.5) D5(-11.5,12.5) D6(-10.5,12.5) D7(-9.5,12.5) D8(-8.5,12.5) D9(-7.5,12.5) D10(-6.5,12.5) D11(-5.5,12.5) D12(-4.5,12.5) D13(-3.5,12.5) D14(-2.5,12.5) D15(-1.5,12.5) D16(-0.5,12.5) D17(0.5,12.5) D18(1.5,12.5) D19(2.5,12.5) D20(3.5,12.5) D21(4.5,12.5) D22(5.5,12.5) D23(6.5,12.5) D24(7.5,12.5) D25(8.5,12.5) D26(9.5,12.5) D27(10.5,12.5) D28(11.5,12.5) D29(12.5,12.5) D30(13.5,12.5) D31(14.5,12.5) D32(15.5,12.5) E1(-15.5,11.5) E2(-14.5,11.5) E3(-13.5,11.5) E4(-12.5,11.5) E5(-11.5,11.5) E6(-10.5,11.5) E7(-9.5,11.5) E8(-8.5,11.5) E9(-7.5,11.5) E10(-6.5,11.5) E11(-5.5,11.5) E12(-4.5,11.5) E13(-3.5,11.5) E14(-2.5,11.5) E15(-1.5,11.5) E16(-0.5,11.5) E17(0.5,11.5) E18(1.5,11.5) E19(2.5,11.5) E20(3.5,11.5) E21(4.5,11.5) E22(5.5,11.5) E23(6.5,11.5) E24(7.5,11.5) E25(8.5,11.5) E26(9.5,11.5) E27(10.5,11.5) E28(11.5,11.5) E29(12.5,11.5) E30(13.5,11.5) E31(14.5,11.5) E32(15.5,11.5) F1(-15.5,10.5) F2(-14.5,10.5) F3(-13.5,10.5) F4(-12.5,10.5) F5(-11.5,10.5) F6(-10.5,10.5) F7(-9.5,10.5) F8(-8.5,10.5) F9(-7.5,10.5) F10(-6.5,10.5) F11(-5.5,10.5) F12(-4.5,10.5) F13(-3.5,10.5) F14(-2.5,10.5) F15(-1.5,10.5) F16(-0.5,10.5) F17(0.5,10.5) F18(1.5,10.5) F19(2.5,10.5) F20(3.5,10.5) F21(4.5,10.5) F22(5.5,10.5) F23(6.5,10.5) F24(7.5,10.5) F25(8.5,10.5) F26(9.5,10.5) F27(10.5,10.5) F28(11.5,10.5) F29(12.5,10.5) F30(13.5,10.5) F31(14.5,10.5) F32(15.5,10.5) G1(-15.5,9.5) G2(-14.5,9.5) G3(-13.5,9.5) G4(-12.5,9.5) G5(-11.5,9.5) G6(-10.5,9.5) G7(-9.5,9.5) G8(-8.5,9.5) G9(-7.5,9.5) G10(-6.5,9.5) G11(-5.5,9.5) G12(-4.5,9.5) G13(-3.5,9.5) G14(-2.5,9.5) G15(-1.5,9.5) G16(-0.5,9.5) G17(0.5,9.5) G18(1.5,9.5) G19(2.5,9.5) G20(3.5,9.5) G21(4.5,9.5) G22(5.5,9.5) G23(6.5,9.5) G24(7.5,9.5) G25(8.5,9.5) G26(9.5,9.5) G27(10.5,9.5) G28(11.5,9.5) G29(12.5,9.5) G30(13.5,9.5) G31(14.5,9.5) G32(15.5,9.5) H1(-15.5,8.5) H2(-14.5,8.5) H3(-13.5,8.5) H4(-12.5,8.5) H5(-11.5,8.5) H6(-10.5,8.5) H7(-9.5,8.5) H8(-8.5,8.5) H9(-7.5,8.5) H10(-6.5,8.5) H11(-5.5,8.5) H12(-4.5,8.5) H13(-3.5,8.5) H14(-2.5,8.5) H15(-1.5,8.5) H16(-0.5,8.5) H17(0.5,8.5) H18(1.5,8.5) H19(2.5,8.5) H20(3.5,8.5) H21(4.5,8.5) H22(5.5,8.5) H23(6.5,8.5) H24(7.5,8.5) H25(8.5,8.5) H26(9.5,8.5) H27(10.5,8.5) H28(11.5,8.5) H29(12.5,8.5) H30(13.5,8.5) H31(14.5,8.5) H32(15.5,8.5) J1(-15.5,7.5) J2(-14.5,7.5) J3(-13.5,7.5) J4(-12.5,7.5) J5(-11.5,7.5) J6(-10.5,7.5) J7(-9.5,7.5) J8(-8.5,7.5) J9(-7.5,7.5) J10(-6.5,7.5) J11(-5.5,7.5) J12(-4.5,7.5) J13(-3.5,7.5) J14(-2.5,7.5) J15(-1.5,7.5) J16(-0.5,7.5) J17(0.5,7.5) J18(1.5,7.5) J19(2.5,7.5) J20(3.5,7.5) J21(4.5,7.5) J22(5.5,7.5) J23(6.5,7.5) J24(7.5,7.5) J25(8.5,7.5) J26(9.5,7.5) J27(10.5,7.5) J28(11.5,7.5) J29(12.5,7.5) J30(13.5,7.5) J31(14.5,7.5) J32(15.5,7.5) K1(-15.5,6.5) K2(-14.5,6.5) K3(-13.5,6.5) K4(-12.5,6.5) K5(-11.5,6.5) K6(-10.5,6.5) K7(-9.5,6.5) K8(-8.5,6.5) K9(-7.5,6.5) K10(-6.5,6.5) K11(-5.5,6.5) K12(-4.5,6.5) K13(-3.5,6.5) K14(-2.5,6.5) K15(-1.5,6.5) K16(-0.5,6.5) K17(0.5,6.5) K18(1.5,6.5) K19(2.5,6.5) K20(3.5,6.5) K21(4.5,6.5) K22(5.5,6.5) K23(6.5,6.5) K24(7.5,6.5) K25(8.5,6.5) K26(9.5,6.5) K27(10.5,6.5) K28(11.5,6.5) K29(12.5,6.5) K30(13.5,6.5) K31(14.5,6.5) K32(15.5,6.5) L1(-15.5,5.5) L2(-14.5,5.5) L3(-13.5,5.5) L4(-12.5,5.5) L5(-11.5,5.5) L6(-10.5,5.5) L7(-9.5,5.5) L8(-8.5,5.5) L9(-7.5,5.5) L10(-6.5,5.5) L11(-5.5,5.5) L12(-4.5,5.5) L13(-3.5,5.5) L14(-2.5,5.5) L15(-1.5,5.5) L16(-0.5,5.5) L17(0.5,5.5) L18(1.5,5.5) L19(2.5,5.5) L20(3.5,5.5) L21(4.5,5.5) L22(5.5,5.5) L23(6.5,5.5) L24(7.5,5.5) L25(8.5,5.5) L26(9.5,5.5) L27(10.5,5.5) L28(11.5,5.5) L29(12.5,5.5) L30(13.5,5.5) L31(14.5,5.5) L32(15.5,5.5) M1(-15.5,4.5) M2(-14.5,4.5) M3(-13.5,4.5) M4(-12.5,4.5) M5(-11.5,4.5) M6(-10.5,4.5) M7(-9.5,4.5) M8(-8.5,4.5) M9(-7.5,4.5) M10(-6.5,4.5) M11(-5.5,4.5) M12(-4.5,4.5) M13(-3.5,4.5) M14(-2.5,4.5) M15(-1.5,4.5) M16(-0.5,4.5) M17(0.5,4.5) M18(1.5,4.5) M19(2.5,4.5) M20(3.5,4.5) M21(4.5,4.5) M22(5.5,4.5) M23(6.5,4.5) M24(7.5,4.5) M25(8.5,4.5) M26(9.5,4.5) M27(10.5,4.5) M28(11.5,4.5) M29(12.5,4.5) M30(13.5,4.5) M31(14.5,4.5) M32(15.5,4.5) N1(-15.5,3.5) N2(-14.5,3.5) N3(-13.5,3.5) N4(-12.5,3.5) N5(-11.5,3.5) N6(-10.5,3.5) N7(-9.5,3.5) N8(-8.5,3.5) N9(-7.5,3.5) N10(-6.5,3.5) N11(-5.5,3.5) N12(-4.5,3.5) N13(-3.5,3.5) N14(-2.5,3.5) N15(-1.5,3.5) N16(-0.5,3.5) N17(0.5,3.5) N18(1.5,3.5) N19(2.5,3.5) N20(3.5,3.5) N21(4.5,3.5) N22(5.5,3.5) N23(6.5,3.5) N24(7.5,3.5) N25(8.5,3.5) N26(9.5,3.5) N27(10.5,3.5) N28(11.5,3.5) N29(12.5,3.5) N30(13.5,3.5) N31(14.5,3.5) N32(15.5,3.5) P1(-15.5,2.5) P2(-14.5,2.5) P3(-13.5,2.5) P4(-12.5,2.5) P5(-11.5,2.5) P6(-10.5,2.5) P7(-9.5,2.5) P8(-8.5,2.5) P9(-7.5,2.5) P10(-6.5,2.5) P11(-5.5,2.5) P12(-4.5,2.5) P13(-3.5,2.5) P14(-2.5,2.5) P15(-1.5,2.5) P16(-0.5,2.5) P17(0.5,2.5) P18(1.5,2.5) P19(2.5,2.5) P20(3.5,2.5) P21(4.5,2.5) P22(5.5,2.5) P23(6.5,2.5) P24(7.5,2.5) P25(8.5,2.5) P26(9.5,2.5) P27(10.5,2.5) P28(11.5,2.5) P29(12.5,2.5) P30(13.5,2.5) P31(14.5,2.5) P32(15.5,2.5) R1(-15.5,1.5) R2(-14.5,1.5) R3(-13.5,1.5) R4(-12.5,1.5) R5(-11.5,1.5) R6(-10.5,1.5) R7(-9.5,1.5) R8(-8.5,1.5) R9(-7.5,1.5) R10(-6.5,1.5) R11(-5.5,1.5) R12(-4.5,1.5) R13(-3.5,1.5) R14(-2.5,1.5) R15(-1.5,1.5) R16(-0.5,1.5) R17(0.5,1.5) R18(1.5,1.5) R19(2.5,1.5) R20(3.5,1.5) R21(4.5,1.5) R22(5.5,1.5) R23(6.5,1.5) R24(7.5,1.5) R25(8.5,1.5) R26(9.5,1.5) R27(10.5,1.5) R28(11.5,1.5) R29(12.5,1.5) R30(13.5,1.5) R31(14.5,1.5) R32(15.5,1.5) T1(-15.5,0.5) T2(-14.5,0.5) T3(-13.5,0.5) T4(-12.5,0.5) T5(-11.5,0.5) T6(-10.5,0.5) T7(-9.5,0.5) T8(-8.5,0.5) T9(-7.5,0.5) T10(-6.5,0.5) T11(-5.5,0.5) T12(-4.5,0.5) T13(-3.5,0.5) T14(-2.5,0.5) T15(-1.5,0.5) T16(-0.5,0.5) T17(0.5,0.5) T18(1.5,0.5) T19(2.5,0.5) T20(3.5,0.5) T21(4.5,0.5) T22(5.5,0.5) T23(6.5,0.5) T24(7.5,0.5) T25(8.5,0.5) T26(9.5,0.5) T27(10.5,0.5) T28(11.5,0.5) T29(12.5,0.5) T30(13.5,0.5) T31(14.5,0.5) T32(15.5,0.5) U1(-15.5,-0.5) U2(-14.5,-0.5) U3(-13.5,-0.5) U4(-12.5,-0.5) U5(-11.5,-0.5) U6(-10.5,-0.5) U7(-9.5,-0.5) U8(-8.5,-0.5) U9(-7.5,-0.5) U10(-6.5,-0.5) U11(-5.5,-0.5) U12(-4.5,-0.5) U13(-3.5,-0.5) U14(-2.5,-0.5) U15(-1.5,-0.5) U16(-0.5,-0.5) U17(0.5,-0.5) U18(1.5,-0.5) U19(2.5,-0.5) U20(3.5,-0.5) U21(4.5,-0.5) U22(5.5,-0.5) U23(6.5,-0.5) U24(7.5,-0.5) U25(8.5,-0.5) U26(9.5,-0.5) U27(10.5,-0.5) U28(11.5,-0.5) U29(12.5,-0.5) U30(13.5,-0.5) U31(14.5,-0.5) U32(15.5,-0.5) V1(-15.5,-1.5) V2(-14.5,-1.5) V3(-13.5,-1.5) V4(-12.5,-1.5) V5(-11.5,-1.5) V6(-10.5,-1.5) V7(-9.5,-1.5) V8(-8.5,-1.5) V9(-7.5,-1.5) V10(-6.5,-1.5) V11(-5.5,-1.5) V12(-4.5,-1.5) V13(-3.5,-1.5) V14(-2.5,-1.5) V15(-1.5,-1.5) V16(-0.5,-1.5) V17(0.5,-1.5) V18(1.5,-1.5) V19(2.5,-1.5) V20(3.5,-1.5) V21(4.5,-1.5) V22(5.5,-1.5) V23(6.5,-1.5) V24(7.5,-1.5) V25(8.5,-1.5) V26(9.5,-1.5) V27(10.5,-1.5) V28(11.5,-1.5) V29(12.5,-1.5) V30(13.5,-1.5) V31(14.5,-1.5) V32(15.5,-1.5) W1(-15.5,-2.5) W2(-14.5,-2.5) W3(-13.5,-2.5) W4(-12.5,-2.5) W5(-11.5,-2.5) W6(-10.5,-2.5) W7(-9.5,-2.5) W8(-8.5,-2.5) W9(-7.5,-2.5) W10(-6.5,-2.5) W11(-5.5,-2.5) W12(-4.5,-2.5) W13(-3.5,-2.5) W14(-2.5,-2.5) W15(-1.5,-2.5) W16(-0.5,-2.5) W17(0.5,-2.5) W18(1.5,-2.5) W19(2.5,-2.5) W20(3.5,-2.5) W21(4.5,-2.5) W22(5.5,-2.5) W23(6.5,-2.5) W24(7.5,-2.5) W25(8.5,-2.5) W26(9.5,-2.5) W27(10.5,-2.5) W28(11.5,-2.5) W29(12.5,-2.5) W30(13.5,-2.5) W31(14.5,-2.5) W32(15.5,-2.5) Y1(-15.5,-3.5) Y2(-14.5,-3.5) Y3(-13.5,-3.5) Y4(-12.5,-3.5) Y5(-11.5,-3.5) Y6(-10.5,-3.5) Y7(-9.5,-3.5) Y8(-8.5,-3.5) Y9(-7.5,-3.5) Y10(-6.5,-3.5) Y11(-5.5,-3.5) Y12(-4.5,-3.5) Y13(-3.5,-3.5) Y14(-2.5,-3.5) Y15(-1.5,-3.5) Y16(-0.5,-3.5) Y17(0.5,-3.5) Y18(1.5,-3.5) Y19(2.5,-3.5) Y20(3.5,-3.5) Y21(4.5,-3.5) Y22(5.5,-3.5) Y23(6.5,-3.5) Y24(7.5,-3.5) Y25(8.5,-3.5) Y26(9.5,-3.5) Y27(10.5,-3.5) Y28(11.5,-3.5) Y29(12.5,-3.5) Y30(13.5,-3.5) Y31(14.5,-3.5) Y32(15.5,-3.5)
HDR2X2_100MIL
  round 1.651 hole 1.067: 1(0,0) 2(0,2.54) 3(2.54,0) 4(2.54,2.54)
HDR2X4_100MIL
  round 1.651 hole 1.067: 1(0,0) 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54)
HDR2X7_100MIL
  rect 3.175x1.27 smd: 1(-2.731,7.62) 2(2.731,7.62) 3(-2.731,5.08) 4(2.731,5.08) 5(-2.731,2.54) 6(2.731,2.54) 7(-2.731,0) 8(2.731,0) 9(-2.731,-2.54) 10(2.731,-2.54) 11(-2.731,-5.08) 12(2.731,-5.08) 13(-2.731,-7.62) 14(2.731,-7.62)
HDR2X10_100MIL
  rect 3.175x1.27 smd: 1(-2.731,11.43) 2(2.731,11.43) 3(-2.731,8.89) 4(2.731,8.89) 5(-2.731,6.35) 6(2.731,6.35) 7(-2.731,3.81) 8(2.731,3.81) 9(-2.731,1.27) 10(2.731,1.27) 11(-2.731,-1.27) 12(2.731,-1.27) 13(-2.731,-3.81) 14(2.731,-3.81) 15(-2.731,-6.35) 16(2.731,-6.35) 17(-2.731,-8.89) 18(2.731,-8.89) 19(-2.731,-11.43) 20(2.731,-11.43)
HDR2X20_100MIL
  rect 3.175x1.27 smd: 1(-2.731,24.13) 2(2.731,24.13) 3(-2.731,21.59) 4(2.731,21.59) 5(-2.731,19.05) 6(2.731,19.05) 7(-2.731,16.51) 8(2.731,16.51) 9(-2.731,13.97) 10(2.731,13.97) 11(-2.731,11.43) 12(2.731,11.43) 13(-2.731,8.89) 14(2.731,8.89) 15(-2.731,6.35) 16(2.731,6.35) 17(-2.731,3.81) 18(2.731,3.81) 19(-2.731,1.27) 20(2.731,1.27) 21(-2.731,-1.27) 22(2.731,-1.27) 23(-2.731,-3.81) 24(2.731,-3.81) 25(-2.731,-6.35) 26(2.731,-6.35) 27(-2.731,-8.89) 28(2.731,-8.89) 29(-2.731,-11.43) 30(2.731,-11.43) 31(-2.731,-13.97) 32(2.731,-13.97) 33(-2.731,-16.51) 34(2.731,-16.51) 35(-2.731,-19.05) 36(2.731,-19.05) 37(-2.731,-21.59) 38(2.731,-21.59) 39(-2.731,-24.13) 40(2.731,-24.13)
HEATSINK-7106D
  custom 2.603x2.603 smd: 1(0,0)
HSSDC2
  round 0.127 hole 2.184 unplated: (-1.825,3.2) (-1.825,-3.2)
  rect 1.524x0.813 smd: 1(-10.325,3.81) 2(-10.325,2.54) 3(-10.325,1.27) 4(-10.325,0) 5(-10.325,-1.27) 6(-10.325,-2.54) 7(-10.325,-3.81)
  rect 4.013x2.54 hole 1.575: 8(-9.025,6.125) 9(-9.025,-6.125) 10(-1.825,6.125) 11(-1.825,-6.125)
  rect 3.023x3.124 hole 1.575: 12(0.975,2.6) 13(0.975,-2.6)
LQFP_32
  rect 1.905x0.457 smd: 1(-4.242,2.8) 2(-4.242,2) 3(-4.242,1.2) 4(-4.242,0.4) 5(-4.242,-0.4) 6(-4.242,-1.2) 7(-4.242,-2) 8(-4.242,-2.8) 17(4.242,-2.8) 18(4.242,-2) 19(4.242,-1.2) 20(4.242,-0.4) 21(4.242,0.4) 22(4.242,1.2) 23(4.242,2) 24(4.242,2.8)
  rect 0.457x1.905 smd: 9(-2.8,-4.242) 10(-2,-4.242) 11(-1.2,-4.242) 12(-0.4,-4.242) 13(0.4,-4.242) 14(1.2,-4.242) 15(2,-4.242) 16(2.8,-4.242) 25(2.8,4.242) 26(2,4.242) 27(1.2,4.242) 28(0.4,4.242) 29(-0.4,4.242) 30(-1.2,4.242) 31(-2,4.242) 32(-2.8,4.242)
MICTOR
  round 0.127 hole 0.813 unplated: (-15.113,-1.016) (15.113,0)
  round 0.127 hole 2.388 unplated: (11.43,0)
  rect 0.432x1.651 smd: 1(5.715,3.531) 2(5.715,-3.531) 3(5.08,3.531) 4(5.08,-3.531) 5(4.445,3.531) 6(4.445,-3.531) 7(3.81,3.531) 8(3.81,-3.531) 9(3.175,3.531) 10(3.175,-3.531) 11(2.54,3.531) 12(2.54,-3.531) 13(1.905,3.531) 14(1.905,-3.531) 15(1.27,3.531) 16(1.27,-3.531) 17(0.635,3.531) 18(0.635,-3.531) 19(0,3.531) 20(0,-3.531) 21(-0.635,3.531) 22(-0.635,-3.531) 23(-1.27,3.531) 24(-1.27,-3.531) 25(-1.905,3.531) 26(-1.905,-3.531) 27(-2.54,3.531) 28(-2.54,-3.531) 29(-3.175,3.531) 30(-3.175,-3.531) 31(-3.81,3.531) 32(-3.81,-3.531) 33(-4.445,3.531) 34(-4.445,-3.531) 35(-5.08,3.531) 36(-5.08,-3.531) 37(-5.715,3.531) 38(-5.715,-3.531)
  round 1.321 hole 0.813: 39(5.08,0) 40(2.54,0) 41(0,0) 42(-2.54,0) 43(-5.08,0)
MOLEX-10X2
  round 0.127 hole 2.997 unplated: (-42.456,5.055) (4.737,5.055)
  rect 1.905x1.905 hole 1.422: 1(0,0)
  round 1.905 hole 1.422: 2(-4.191,0) 3(-8.382,0) 4(-12.573,0) 5(-16.764,0) 6(-20.955,0) 7(-25.146,0) 8(-29.337,0) 9(-33.528,0) 10(-37.719,0) 11(0,5.512) 12(-4.191,5.512) 13(-8.382,5.512) 14(-12.573,5.512) 15(-16.764,5.512) 16(-20.955,5.512) 17(-25.146,5.512) 18(-29.337,5.512) 19(-33.528,5.512) 20(-37.719,5.512)
PACKAGE_D
  rect 2.007x1.803 smd: 1(-2.1,2.54) 2(-2.1,0) 3(-2.1,-2.54) 4(2.1,-2.54) 5(2.1,0) 6(2.1,2.54)
PQFP100_720X956
  rect 2.54x0.406 smd: 1(-8.382,9.425) 2(-8.382,8.775) 3(-8.382,8.125) 4(-8.382,7.475) 5(-8.382,6.825) 6(-8.382,6.175) 7(-8.382,5.525) 8(-8.382,4.875) 9(-8.382,4.225) 10(-8.382,3.575) 11(-8.382,2.925) 12(-8.382,2.275) 13(-8.382,1.625) 14(-8.382,0.975) 15(-8.382,0.325) 16(-8.382,-0.325) 17(-8.382,-0.975) 18(-8.382,-1.625) 19(-8.382,-2.275) 20(-8.382,-2.925) 21(-8.382,-3.575) 22(-8.382,-4.225) 23(-8.382,-4.875) 24(-8.382,-5.525) 25(-8.382,-6.175) 26(-8.382,-6.825) 27(-8.382,-7.475) 28(-8.382,-8.125) 29(-8.382,-8.775) 30(-8.382,-9.425) 51(8.382,-9.425) 52(8.382,-8.775) 53(8.382,-8.125) 54(8.382,-7.475) 55(8.382,-6.825) 56(8.382,-6.175) 57(8.382,-5.525) 58(8.382,-4.875) 59(8.382,-4.225) 60(8.382,-3.575) 61(8.382,-2.925) 62(8.382,-2.275) 63(8.382,-1.625) 64(8.382,-0.975) 65(8.382,-0.325) 66(8.382,0.325) 67(8.382,0.975) 68(8.382,1.625) 69(8.382,2.275) 70(8.382,2.925) 71(8.382,3.575) 72(8.382,4.225) 73(8.382,4.875) 74(8.382,5.525) 75(8.382,6.175) 76(8.382,6.825) 77(8.382,7.475) 78(8.382,8.125) 79(8.382,8.775) 80(8.382,9.425)
  rect 0.406x2.54 smd: 31(-6.175,-11.379) 32(-5.525,-11.379) 33(-4.875,-11.379) 34(-4.225,-11.379) 35(-3.575,-11.379) 36(-2.925,-11.379) 37(-2.275,-11.379) 38(-1.625,-11.379) 39(-0.975,-11.379) 40(-0.325,-11.379) 41(0.325,-11.379) 42(0.975,-11.379) 43(1.625,-11.379) 44(2.275,-11.379) 45(2.925,-11.379) 46(3.575,-11.379) 47(4.225,-11.379) 48(4.875,-11.379) 49(5.525,-11.379) 50(6.175,-11.379) 81(6.175,11.379) 82(5.525,11.379) 83(4.875,11.379) 84(4.225,11.379) 85(3.575,11.379) 86(2.925,11.379) 87(2.275,11.379) 88(1.625,11.379) 89(0.975,11.379) 90(0.325,11.379) 91(-0.325,11.379) 92(-0.975,11.379) 93(-1.625,11.379) 94(-2.275,11.379) 95(-2.925,11.379) 96(-3.575,11.379) 97(-4.225,11.379) 98(-4.875,11.379) 99(-5.525,11.379) 100(-6.175,11.379)
QSOP16
  rect 1.524x0.33 smd: 1(-2.413,2.223) 2(-2.413,1.587) 3(-2.413,0.953) 4(-2.413,0.318) 5(-2.413,-0.318) 6(-2.413,-0.953) 7(-2.413,-1.587) 8(-2.413,-2.223) 9(2.413,-2.223) 10(2.413,-1.587) 11(2.413,-0.953) 12(2.413,-0.318) 13(2.413,0.318) 14(2.413,0.953) 15(2.413,1.587) 16(2.413,2.223)
RES_0402
  rect 0.508x0.508 smd: 1(0,0.445) 2(0,-0.445)
RES_0603
  rect 0.813x1.067 smd: 1(0,0.85) 2(0,-0.85)
RES_0805
  rect 1.6x1.321 smd: 1(0,0.95) 2(0,-0.95)
RJ426
  round 0.127 hole 3.2 unplated: (-10.16,6.35) (1.27,6.35)
  rect 1.397x1.397 hole 0.914: 1(0,0)
  round 1.397 hole 0.914: 2(-1.27,-2.54) 3(-2.54,0) 4(-3.81,-2.54) 5(-5.08,0) 6(-6.35,-2.54) 7(-7.62,0) 8(-8.89,-2.54)
  round 1.524 hole 1.067: 9(2.184,10.414) 10(-0.356,10.414) 11(-8.534,10.414) 12(-11.074,10.414)
  round 2.083 hole 1.575: 13(-12.192,3.302) 14(3.302,3.302)
RN_SMT
  rect 0.889x0.432 smd: 1(-0.817,1.839) 8(-0.817,-1.839) 9(0.817,-1.839) 16(0.817,1.839)
  rect 0.889x0.254 smd: 2(-0.817,1.25) 3(-0.817,0.75) 4(-0.817,0.25) 5(-0.817,-0.25) 6(-0.817,-0.75) 7(-0.817,-1.25) 10(0.817,-1.25) 11(0.817,-0.75) 12(0.817,-0.25) 13(0.817,0.25) 14(0.817,0.75) 15(0.817,1.25)
RPACK8
  rect 0.889x0.432 smd: 1(-0.944,1.839) 8(-0.944,-1.839) 9(0.944,-1.839) 16(0.944,1.839)
  rect 0.889x0.254 smd: 2(-0.944,1.25) 3(-0.944,0.75) 4(-0.944,0.25) 5(-0.944,-0.25) 6(-0.944,-0.75) 7(-0.944,-1.25) 10(0.944,-1.25) 11(0.944,-0.75) 12(0.944,-0.25) 13(0.944,0.25) 14(0.944,0.75) 15(0.944,1.25)
SFP
  round 0.127 hole 1.575 unplated: (-1.4,4.1) (8.2,4.1)
  rect 0.533x2.007 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0) 11(6.8,8.2) 12(6,8.2) 13(5.2,8.2) 14(4.4,8.2) 15(3.6,8.2) 16(2.8,8.2) 17(2,8.2) 18(1.2,8.2) 19(0.4,8.2) 20(-0.4,8.2)
  rect 1.981x1.981 hole 1.067: 21(-3.721,-26.765) 22(4.864,-26.765) 23(10.503,-21.765) 24(-3.721,-16.765) 25(10.503,-11.765) 26(7.353,-6.765) 27(1.968,-6.765) 28(-3.721,-6.765) 31(10.503,-1.765) 37(10.503,8.235)
  round 1.473 hole 1.067: 29(-3.721,-3.965) 30(10.503,-3.965) 32(-3.721,0.735) 33(10.503,0.735) 35(-3.721,5.735) 36(10.503,5.735) 38(-1.409,10.335) 39(3.391,10.335) 40(8.191,10.335)
  rect 1.981x1.981 hole 0.914: 34(-3.721,3.235)
SMT
  round 0.127 hole 1.397 unplated: (-17.2,0) (17.2,0)
  rect 0.61x2.108 smd: 1(-15.5,-1.95) 2(-15.5,1.95) 3(-14.5,-1.95) 4(-14.5,1.95) 5(-13.5,-1.95) 6(-13.5,1.95) 7(-12.5,-1.95) 8(-12.5,1.95) 9(-11.5,-1.95) 10(-11.5,1.95) 11(-10.5,-1.95) 12(-10.5,1.95) 13(-9.5,-1.95) 14(-9.5,1.95) 15(-8.5,-1.95) 16(-8.5,1.95) 17(-7.5,-1.95) 18(-7.5,1.95) 19(-6.5,-1.95) 20(-6.5,1.95) 21(-5.5,-1.95) 22(-5.5,1.95) 23(-4.5,-1.95) 24(-4.5,1.95) 25(-3.5,-1.95) 26(-3.5,1.95) 27(-2.5,-1.95) 28(-2.5,1.95) 29(-1.5,-1.95) 30(-1.5,1.95) 31(-0.5,-1.95) 32(-0.5,1.95) 33(0.5,-1.95) 34(0.5,1.95) 35(1.5,-1.95) 36(1.5,1.95) 37(2.5,-1.95) 38(2.5,1.95) 39(3.5,-1.95) 40(3.5,1.95) 41(4.5,-1.95) 42(4.5,1.95) 43(5.5,-1.95) 44(5.5,1.95) 45(6.5,-1.95) 46(6.5,1.95) 47(7.5,-1.95) 48(7.5,1.95) 49(8.5,-1.95) 50(8.5,1.95) 51(9.5,-1.95) 52(9.5,1.95) 53(10.5,-1.95) 54(10.5,1.95) 55(11.5,-1.95) 56(11.5,1.95) 57(12.5,-1.95) 58(12.5,1.95) 59(13.5,-1.95) 60(13.5,1.95) 61(14.5,-1.95) 62(14.5,1.95) 63(15.5,-1.95) 64(15.5,1.95)
SMT_A_PROBE
  round 1.346 hole 0.813: (-14.981,2.413) (-14.981,-2.413) (14.991,-2.413)
  round 0.127 hole 0.813 unplated: (-14.981,0) (14.991,2.413)
  oval 0.584x0.711 smd: A1(-13,-1.27) A2(-12,-1.27) A3(-11,-1.27) A4(-10,-1.27) A5(-9,-1.27) A6(-8,-1.27) A7(-7,-1.27) A8(-6,-1.27) A9(-5,-1.27) A10(-4,-1.27) A11(-3,-1.27) A12(-2,-1.27) A13(-1,-1.27) A14(0,-1.27) A15(1,-1.27) A16(2,-1.27) A17(3,-1.27) A18(4,-1.27) A19(5,-1.27) A20(6,-1.27) A21(7,-1.27) A22(8,-1.27) A23(9,-1.27) A24(10,-1.27) A25(11,-1.27) A26(12,-1.27) A27(13,-1.27) B1(-13,1.27) B2(-12,1.27) B3(-11,1.27) B4(-10,1.27) B5(-9,1.27) B6(-8,1.27) B7(-7,1.27) B8(-6,1.27) B9(-5,1.27) B10(-4,1.27) B11(-3,1.27) B12(-2,1.27) B13(-1,1.27) B14(0,1.27) B15(1,1.27) B16(2,1.27) B17(3,1.27) B18(4,1.27) B19(5,1.27) B20(6,1.27) B21(7,1.27) B22(8,1.27) B23(9,1.27) B24(10,1.27) B25(11,1.27) B26(12,1.27) B27(13,1.27)
SO8
  oval 2.032x0.635 smd: 1(-2.54,1.905) 2(-2.54,0.635) 3(-2.54,-0.635) 4(-2.54,-1.905) 5(2.54,-1.905) 6(2.54,-0.635) 7(2.54,0.635) 8(2.54,1.905)
SO8N
  rect 0.584x2.184 smd: 1(0,-2.608) 2(1.27,-2.608) 3(2.54,-2.608) 4(3.81,-2.608) 5(3.81,2.608) 6(2.54,2.608) 7(1.27,2.608) 8(0,2.608)
SO24
  rect 2.184x0.813 smd: 1(-4.801,6.985) 2(-4.801,5.715) 3(-4.801,4.445) 4(-4.801,3.175) 5(-4.801,1.905) 6(-4.801,0.635) 7(-4.801,-0.635) 8(-4.801,-1.905) 9(-4.801,-3.175) 10(-4.801,-4.445) 11(-4.801,-5.715) 12(-4.801,-6.985) 13(4.801,-6.985) 14(4.801,-5.715) 15(4.801,-4.445) 16(4.801,-3.175) 17(4.801,-1.905) 18(4.801,-0.635) 19(4.801,0.635) 20(4.801,1.905) 21(4.801,3.175) 22(4.801,4.445) 23(4.801,5.715) 24(4.801,6.985)
SO40
  rect 1.803x0.305 smd: 1(-2.7,4.75) 2(-2.7,4.25) 3(-2.7,3.75) 4(-2.7,3.25) 5(-2.7,2.75) 6(-2.7,2.25) 7(-2.7,1.75) 8(-2.7,1.25) 9(-2.7,0.75) 10(-2.7,0.25) 11(-2.7,-0.25) 12(-2.7,-0.75) 13(-2.7,-1.25) 14(-2.7,-1.75) 15(-2.7,-2.25) 16(-2.7,-2.75) 17(-2.7,-3.25) 18(-2.7,-3.75) 19(-2.7,-4.25) 20(-2.7,-4.75) 21(2.7,-4.75) 22(2.7,-4.25) 23(2.7,-3.75) 24(2.7,-3.25) 25(2.7,-2.75) 26(2.7,-2.25) 27(2.7,-1.75) 28(2.7,-1.25) 29(2.7,-0.75) 30(2.7,-0.25) 31(2.7,0.25) 32(2.7,0.75) 33(2.7,1.25) 34(2.7,1.75) 35(2.7,2.25) 36(2.7,2.75) 37(2.7,3.25) 38(2.7,3.75) 39(2.7,4.25) 40(2.7,4.75)
SOG_05
  rect 1.499x0.305 smd: 1(-2.036,1) 2(-2.036,0.5) 3(-2.036,0) 4(-2.036,-0.5) 5(-2.036,-1) 6(2.036,-1) 7(2.036,-0.5) 8(2.036,0) 9(2.036,0.5) 10(2.036,1)
SOG_50
  rect 2.21x0.61 smd: 1(-2.6,4.445) 2(-2.6,3.175) 3(-2.6,1.905) 4(-2.6,0.635) 5(-2.6,-0.635) 6(-2.6,-1.905) 7(-2.6,-3.175) 8(-2.6,-4.445) 9(2.6,-4.445) 10(2.6,-3.175) 11(2.6,-1.905) 12(2.6,-0.635) 13(2.6,0.635) 14(2.6,1.905) 15(2.6,3.175) 16(2.6,4.445)
SOG_65
  rect 2.032x0.635 smd: 1(-2.794,1.905) 2(-2.794,0.635) 3(-2.794,-0.635) 4(-2.794,-1.905) 5(2.794,-1.905) 6(2.794,-0.635) 7(2.794,0.635) 8(2.794,1.905)
SOIC8
  rect 2.032x0.635 smd: 1(-2.794,1.905) 2(-2.794,0.635) 3(-2.794,-0.635) 4(-2.794,-1.905) 5(2.794,-1.905) 6(2.794,-0.635) 7(2.794,0.635) 8(2.794,1.905)
SOIC16F
  oval 2.032x0.635 smd: 1(-3.81,4.445) 2(-3.81,3.175) 3(-3.81,1.905) 4(-3.81,0.635) 5(-3.81,-0.635) 6(-3.81,-1.905) 7(-3.81,-3.175) 8(-3.81,-4.445) 9(3.81,-4.445) 10(3.81,-3.175) 11(3.81,-1.905) 12(3.81,-0.635) 13(3.81,0.635) 14(3.81,1.905) 15(3.81,3.175) 16(3.81,4.445)
SOIC20
  rect 2.21x0.61 smd: 1(-4.477,5.715) 2(-4.477,4.445) 3(-4.477,3.175) 4(-4.477,1.905) 5(-4.477,0.635) 6(-4.477,-0.635) 7(-4.477,-1.905) 8(-4.477,-3.175) 9(-4.477,-4.445) 10(-4.477,-5.715) 11(4.477,-5.715) 12(4.477,-4.445) 13(4.477,-3.175) 14(4.477,-1.905) 15(4.477,-0.635) 16(4.477,0.635) 17(4.477,1.905) 18(4.477,3.175) 19(4.477,4.445) 20(4.477,5.715)
SOT23-5
  rect 1.016x0.508 smd: 1(-1.321,0.95) 2(-1.321,0) 3(-1.321,-0.95) 4(1.321,-0.95) 5(1.321,0.95)
SSOT6
  oval 1.778x0.508 smd: 1(-1.143,0.95) 2(-1.143,0) 3(-1.143,-0.95) 4(1.143,-0.95) 5(1.143,0) 6(1.143,0.95)
TEK_PROBE
  round 0.127 hole 3.505 unplated: (-12.84,0) (12.814,0)
  round 0.127 hole 1.702 unplated: (9.131,1.143)
  rect 0.406x0.813 smd: A1(7.556,-1.575) A2(6.642,-1.575) A3(5.728,-1.575) A4(3.899,-1.575) A5(2.985,-1.575) A6(2.07,-1.575) A7(0.241,-1.575) A8(-0.673,-1.575) A9(-1.587,-1.575) A10(-3.416,-1.575) A11(-4.331,-1.575) A12(-5.245,-1.575) A13(-7.074,-1.575) A14(-7.988,-1.575) A15(-8.903,-1.575) B1(5.22,1.575) B2(4.305,1.575) B3(3.391,1.575) B4(1.562,1.575) B5(0.648,1.575) B6(-0.267,1.575) B7(-2.095,1.575) B8(-3.01,1.575) B9(-3.924,1.575) B10(-5.753,1.575) B11(-6.668,1.575) B12(-7.582,1.575)
TH-CONN-2-P1
  rect 1.524x1.524 hole 1.067: 1(0,0)
  round 1.524 hole 1.067: 2(2.54,0)
THRU_HOLE
  rect 2.819x2.769 smd: 1(0,3.15) 2(0,-3.15)
TO263
  rect 1.067x2.159 smd: 1(-2.54,-8.319) 2(0,-8.319) 3(2.54,-8.319)
  rect 10.795x10.414 smd: 4(0,0)
TO263_5
  rect 5.08x1.143 smd: 1(-8.052,3.404) 2(-8.052,1.702) 3(-8.052,0) 4(-8.052,-1.702) 5(-8.052,-3.404)
  rect 10.414x10.795 smd: 6(1.092,0)
TQFP128P
  round 1.016 smd: (0,0)
  rect 1.778x0.254 smd: 1(-7.5,6.2) 2(-7.5,5.8) 3(-7.5,5.4) 4(-7.5,5) 5(-7.5,4.6) 6(-7.5,4.2) 7(-7.5,3.8) 8(-7.5,3.4) 9(-7.5,3) 10(-7.5,2.6) 11(-7.5,2.2) 12(-7.5,1.8) 13(-7.5,1.4) 14(-7.5,1) 15(-7.5,0.6) 16(-7.5,0.2) 17(-7.5,-0.2) 18(-7.5,-0.6) 19(-7.5,-1) 20(-7.5,-1.4) 21(-7.5,-1.8) 22(-7.5,-2.2) 23(-7.5,-2.6) 24(-7.5,-3) 25(-7.5,-3.4) 26(-7.5,-3.8) 27(-7.5,-4.2) 28(-7.5,-4.6) 29(-7.5,-5) 30(-7.5,-5.4) 31(-7.5,-5.8) 32(-7.5,-6.2) 65(7.5,-6.2) 66(7.5,-5.8) 67(7.5,-5.4) 68(7.5,-5) 69(7.5,-4.6) 70(7.5,-4.2) 71(7.5,-3.8) 72(7.5,-3.4) 73(7.5,-3) 74(7.5,-2.6) 75(7.5,-2.2) 76(7.5,-1.8) 77(7.5,-1.4) 78(7.5,-1) 79(7.5,-0.6) 80(7.5,-0.2) 81(7.5,0.2) 82(7.5,0.6) 83(7.5,1) 84(7.5,1.4) 85(7.5,1.8) 86(7.5,2.2) 87(7.5,2.6) 88(7.5,3) 89(7.5,3.4) 90(7.5,3.8) 91(7.5,4.2) 92(7.5,4.6) 93(7.5,5) 94(7.5,5.4) 95(7.5,5.8) 96(7.5,6.2)
  rect 0.254x1.778 smd: 33(-6.2,-7.5) 34(-5.8,-7.5) 35(-5.4,-7.5) 36(-5,-7.5) 37(-4.6,-7.5) 38(-4.2,-7.5) 39(-3.8,-7.5) 40(-3.4,-7.5) 41(-3,-7.5) 42(-2.6,-7.5) 43(-2.2,-7.5) 44(-1.8,-7.5) 45(-1.4,-7.5) 46(-1,-7.5) 47(-0.6,-7.5) 48(-0.2,-7.5) 49(0.2,-7.5) 50(0.6,-7.5) 51(1,-7.5) 52(1.4,-7.5) 53(1.8,-7.5) 54(2.2,-7.5) 55(2.6,-7.5) 56(3,-7.5) 57(3.4,-7.5) 58(3.8,-7.5) 59(4.2,-7.5) 60(4.6,-7.5) 61(5,-7.5) 62(5.4,-7.5) 63(5.8,-7.5) 64(6.2,-7.5) 97(6.2,7.5) 98(5.8,7.5) 99(5.4,7.5) 100(5,7.5) 101(4.6,7.5) 102(4.2,7.5) 103(3.8,7.5) 104(3.4,7.5) 105(3,7.5) 106(2.6,7.5) 107(2.2,7.5) 108(1.8,7.5) 109(1.4,7.5) 110(1,7.5) 111(0.6,7.5) 112(0.2,7.5) 113(-0.2,7.5) 114(-0.6,7.5) 115(-1,7.5) 116(-1.4,7.5) 117(-1.8,7.5) 118(-2.2,7.5) 119(-2.6,7.5) 120(-3,7.5) 121(-3.4,7.5) 122(-3.8,7.5) 123(-4.2,7.5) 124(-4.6,7.5) 125(-5,7.5) 126(-5.4,7.5) 127(-5.8,7.5) 128(-6.2,7.5)
TSM-105-01-L-DV
  rect 3.81x1.27 smd: 1(-2.54,5.08) 2(2.54,5.08) 3(-2.54,2.54) 4(2.54,2.54) 5(-2.54,0) 6(2.54,0) 7(-2.54,-2.54) 8(2.54,-2.54) 9(-2.54,-5.08) 10(2.54,-5.08)
TSM-110-01-G-DV
  rect 3.81x1.27 smd: 1(-2.54,11.43) 2(2.54,11.43) 3(-2.54,8.89) 4(2.54,8.89) 5(-2.54,6.35) 6(2.54,6.35) 7(-2.54,3.81) 8(2.54,3.81) 9(-2.54,1.27) 10(2.54,1.27) 11(-2.54,-1.27) 12(2.54,-1.27) 13(-2.54,-3.81) 14(2.54,-3.81) 15(-2.54,-6.35) 16(2.54,-6.35) 17(-2.54,-8.89) 18(2.54,-8.89) 19(-2.54,-11.43) 20(2.54,-11.43)
TSOP48
  rect 1.778x0.305 smd: 1(-9.5,5.75) 2(-9.5,5.25) 3(-9.5,4.75) 4(-9.5,4.25) 5(-9.5,3.75) 6(-9.5,3.25) 7(-9.5,2.75) 8(-9.5,2.25) 9(-9.5,1.75) 10(-9.5,1.25) 11(-9.5,0.75) 12(-9.5,0.25) 13(-9.5,-0.25) 14(-9.5,-0.75) 15(-9.5,-1.25) 16(-9.5,-1.75) 17(-9.5,-2.25) 18(-9.5,-2.75) 19(-9.5,-3.25) 20(-9.5,-3.75) 21(-9.5,-4.25) 22(-9.5,-4.75) 23(-9.5,-5.25) 24(-9.5,-5.75) 25(9.5,-5.75) 26(9.5,-5.25) 27(9.5,-4.75) 28(9.5,-4.25) 29(9.5,-3.75) 30(9.5,-3.25) 31(9.5,-2.75) 32(9.5,-2.25) 33(9.5,-1.75) 34(9.5,-1.25) 35(9.5,-0.75) 36(9.5,-0.25) 37(9.5,0.25) 38(9.5,0.75) 39(9.5,1.25) 40(9.5,1.75) 41(9.5,2.25) 42(9.5,2.75) 43(9.5,3.25) 44(9.5,3.75) 45(9.5,4.25) 46(9.5,4.75) 47(9.5,5.25) 48(9.5,5.75)
TSSOP8
  oval 1.778x0.381 smd: 1(-2.921,0.975) 2(-2.921,0.325) 3(-2.921,-0.325) 4(-2.921,-0.975) 5(2.921,-0.975) 6(2.921,-0.325) 7(2.921,0.325) 8(2.921,0.975)
TSSOP20
  rect 1.651x0.356 smd: 1(-2.781,2.925) 2(-2.781,2.275) 3(-2.781,1.625) 4(-2.781,0.975) 5(-2.781,0.325) 6(-2.781,-0.325) 7(-2.781,-0.975) 8(-2.781,-1.625) 9(-2.781,-2.275) 10(-2.781,-2.925) 11(2.781,-2.925) 12(2.781,-2.275) 13(2.781,-1.625) 14(2.781,-0.975) 15(2.781,-0.325) 16(2.781,0.325) 17(2.781,0.975) 18(2.781,1.625) 19(2.781,2.275) 20(2.781,2.925)
TSSOP48
  rect 1.905x0.305 smd: 1(-3.641,5.75) 2(-3.641,5.25) 3(-3.641,4.75) 4(-3.641,4.25) 5(-3.641,3.75) 6(-3.641,3.25) 7(-3.641,2.75) 8(-3.641,2.25) 9(-3.641,1.75) 10(-3.641,1.25) 11(-3.641,0.75) 12(-3.641,0.25) 13(-3.641,-0.25) 14(-3.641,-0.75) 15(-3.641,-1.25) 16(-3.641,-1.75) 17(-3.641,-2.25) 18(-3.641,-2.75) 19(-3.641,-3.25) 20(-3.641,-3.75) 21(-3.641,-4.25) 22(-3.641,-4.75) 23(-3.641,-5.25) 24(-3.641,-5.75) 25(3.641,-5.75) 26(3.641,-5.25) 27(3.641,-4.75) 28(3.641,-4.25) 29(3.641,-3.75) 30(3.641,-3.25) 31(3.641,-2.75) 32(3.641,-2.25) 33(3.641,-1.75) 34(3.641,-1.25) 35(3.641,-0.75) 36(3.641,-0.25) 37(3.641,0.25) 38(3.641,0.75) 39(3.641,1.25) 40(3.641,1.75) 41(3.641,2.25) 42(3.641,2.75) 43(3.641,3.25) 44(3.641,3.75) 45(3.641,4.25) 46(3.641,4.75) 47(3.641,5.25) 48(3.641,5.75)
TSSOP_8
  rect 1.524x0.406 smd: 1(-2.095,0.975) 2(-2.095,0.325) 3(-2.095,-0.325) 4(-2.095,-0.975) 5(2.095,-0.975) 6(2.095,-0.325) 7(2.095,0.325) 8(2.095,0.975)
unnamed#2
  round 1.27 smd: (0,0)
VERT_SM_SMA
  round 1.702 smd: 1(0,0)
  round 2.083 hole 1.575: 2(-2.54,2.54) 3(2.54,2.54) 4(-2.54,-2.54) 5(2.54,-2.54)
XPAK1
  round 2.54 hole 1.575: (-19.05,0) (-19.05,-11.43) (-19.05,-24.13) (-19.05,-36.83) (-19.05,-49.53) (19.05,3.81) (19.05,-17.78) (19.05,-30.48) (19.05,-43.18) (19.05,-55.88)
  round 0.127 hole 1.575 unplated: (-14.8,0) (14.8,0)
  rect 0.508x2.032 smd: 1(-13.4,-4.1) 2(-12.6,-4.1) 3(-11.8,-4.1) 4(-11,-4.1) 5(-10.2,-4.1) 6(-9.4,-4.1) 7(-8.6,-4.1) 8(-7.8,-4.1) 9(-7,-4.1) 10(-6.2,-4.1) 11(-5.4,-4.1) 12(-4.6,-4.1) 13(-3.8,-4.1) 14(-3,-4.1) 15(-2.2,-4.1) 16(-1.4,-4.1) 17(-0.6,-4.1) 18(0.2,-4.1) 19(1,-4.1) 20(1.8,-4.1) 21(2.6,-4.1) 22(3.4,-4.1) 23(4.2,-4.1) 24(5,-4.1) 25(5.8,-4.1) 26(6.6,-4.1) 27(7.4,-4.1) 28(8.2,-4.1) 29(9,-4.1) 30(9.8,-4.1) 31(10.6,-4.1) 32(11.4,-4.1) 33(12.2,-4.1) 34(13,-4.1) 35(13.8,-4.1) 36(13.4,4.1) 37(12.6,4.1) 38(11.8,4.1) 39(11,4.1) 40(10.2,4.1) 41(9.4,4.1) 42(8.6,4.1) 43(7.8,4.1) 44(7,4.1) 45(6.2,4.1) 46(5.4,4.1) 47(4.6,4.1) 48(3.8,4.1) 49(3,4.1) 50(2.2,4.1) 51(1.4,4.1) 52(0.6,4.1) 53(-0.2,4.1) 54(-1,4.1) 55(-1.8,4.1) 56(-2.6,4.1) 57(-3.4,4.1) 58(-4.2,4.1) 59(-5,4.1) 60(-5.8,4.1) 61(-6.6,4.1) 62(-7.4,4.1) 63(-8.2,4.1) 64(-9,4.1) 65(-9.8,4.1) 66(-10.6,4.1) 67(-11.4,4.1) 68(-12.2,4.1) 69(-13,4.1) 70(-13.8,4.1)

## Nets
1.5V_A_INT: C19.1 HS2.1(HS1) R6.1 U2.2(VO) U2.4
1.5V_ENABLE: C143.1 J113.2 U36.2
1.5V_GX_INT: C34.2 C36.2 C37.2 C38.1 C39.1 C40.1 C49.1 C128.1 C148.1 C149.2 C150.2 C151.2 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.1 C164.1 C165.1 C166.1 C171.1 C172.1 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.2 C183.2 C184.2 C185.2 C186.2 C187.2 C188.2 C189.2 C190.2 C191.2 C192.2 C193.2 C194.2 C195.2 C196.1 C197.1 C198.1 C199.2 C200.1 C201.1 C211.2 C212.2 C213.2 C214.1 C215.1 C216.1 C217.2 C218.1 C219.2 C220.1 C226.1 C227.2 C228.1 C241.1 C245.1 C246.1 C247.2 C248.1 C250.1 C251.1 C253.1 C255.1 C256.2 C257.1 C258.1 C260.1 C261.2 C262.1 C264.1 C265.1 C267.2 C268.1 C269.1 C272.1 C273.1 C274.2 C275.2 C276.1 C277.2 C285.2 C289.2 C296.2 C298.1 C302.1 C305.2 C306.2 C311.1 C312.1 C320.2 C321.1 C323.2 C327.2 C330.2 C335.2 C338.2 C342.2 C343.2 C348.2 C349.2 C354.2 C356.2 C391.2 C393.1 C395.1 C396.2 C397.1 C746.1 C787.1 R249.2 R250.2 R251.2 R252.2 R253.2 R254.2 R255.2 R256.2 R257.2 R258.2 R330.2 R331.2 R332.2 R333.2
1.5V_OUT: C28.1 U36.4 U36.5
1.5V_PLL: C45.1 C46.1 C47.1 C287.2 C295.2 C314.1 C329.1 C364.1 C365.1 C366.1 C370.2 C371.2 C374.1 C375.2 C378.1 C379.2 C381.1 C385.1 C386.2 C400.1 C401.1 C409.2 C410.1 C411.1 C412.1 C413.1 C438.1 C459.1 C463.1 C469.1 C470.2 C480.2 C481.1 C533.1 C537.2 C541.2 C544.1 C559.1 C586.1 C593.2 C594.2 C602.1 C603.2 C604.2 C610.1 C611.1 C616.1 C627.1 C698.1 U15.AG16 U15.AG17 U15.AJ2 U15.AJ31 U15.D2 U15.D31 U15.E16 U15.G17 U15.T8 U15.T25 U15.U8 U15.U25
1.5V_S_INT: C126.1 C439.1 C440.1 C441.2 C442.2 C443.2 C444.2 C445.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.2 C452.1 C453.1 C454.2 C455.2 C456.2 C457.1 C458.1 C465.2 C466.2 C471.2 C472.2 C474.2 C475.2 C476.2 C477.2 C483.2 C484.2 C487.2 C488.2 C491.2 C492.1 C494.2 C498.1 C499.2 C500.1 C501.2 C503.1 C504.1 C507.2 C508.2 C511.1 C512.2 C513.1 C514.2 C515.2 C516.2 C517.1 C520.1 C521.2 C523.1 C525.2 C527.2 C528.2 C529.1 C530.1 C534.1 C536.2 C538.1 C539.2 C542.1 C545.2 C546.2 C547.2 C548.1 C549.1 C550.1 C552.2 C554.1 C556.1 C557.1 C558.1 C560.1 C561.1 C562.1 C563.1 C565.2 C566.2 C568.1 C569.1 C570.1 C571.2 C573.1 C574.2 C576.1 C577.1 C579.2 C580.1 C581.1 C583.1 C584.2 C585.1 C591.1 C592.1 C596.1 C597.1 C599.2 C600.2 C605.1 C606.2 C608.2 C609.2 C614.1 C615.2 C617.2 C618.1 C619.1 C620.1 C621.2 C622.2 C623.1 C624.1 C625.1 C626.1 C628.2 C629.1 C630.1 C631.1 C632.1 C633.2 C634.1 C635.1 C636.1 C637.1 C786.1 U15.AD16 U15.AF16 U15.AJ3 U15.AJ30 U15.D3 U15.D30 U15.H16 U15.J16 U15.M12 U15.M14 U15.M19 U15.M21 U15.N13 U15.N15 U15.N18 U15.N20 U15.P12 U15.P14 U15.P16 U15.P17 U15.P19 U15.P21 U15.R13 U15.R15 U15.R18 U15.R20 U15.R22 U15.T9 U15.T14 U15.T16 U15.T17 U15.T19 U15.U14 U15.U16 U15.U17 U15.U19 U15.U24 U15.V11 U15.V13 U15.V15 U15.V18 U15.V20 U15.W14 U15.W16 U15.W17 U15.W19 U15.Y13 U15.Y15 U15.Y18 U15.Y20
1.5V_VCCP: C778.2 C779.2 C780.2 C781.2
1.5V_XCVR: C33.1 C35.2 C136.2 C137.1 C138.2 C139.2 C204.2 C205.2 C206.2 C207.2 C229.1 C230.2 C231.2 C243.1 C249.1 C252.1 C286.2 C290.2 C303.1 C322.2 C326.1 C355.2 C360.1 C372.1 C373.1 C384.1 C387.2 C399.1 C402.1 C403.2 C427.1 C428.1 C699.1 C788.1 C789.1
1.5V_XCVR1: C754.2 C755.2 C756.2 C757.2
1.5V_XCVR2: C758.2 C759.2 C760.2 C761.2
1.5V_XCVR3: C762.2 C763.2 C764.2 C765.2
1.5V_XCVR4: C766.2 C767.2 C768.2 C769.2
1.5V_XCVR5: C770.2 C771.2 C772.2 C773.2
1.8V_DDR: XU2.51 XU2.53 XU2.56 XU2.59 XU2.62 XU2.64 XU2.67 XU2.69 XU2.72 XU2.75 XU2.78 XU2.170 XU2.172 XU2.175 XU2.178 XU2.181 XU2.184 XU2.187 XU2.189 XU2.191 XU2.194 XU2.197 XU2.238
1.25V: C716.1 C717.1
1.25VREF: C719.1 R324.1 U53.4
2.5V: C697.1 C714.1 C785.1 R326.1 U53.6 U53.7
2.5V_DDR_VDD: C129.1 C130.2 C132.1 C135.2 C140.1 C141.2 C142.2 C144.1 C168.2 C169.1 C202.1 C203.1 C208.2 C233.1 C234.1 C237.2 C242.1 C259.2 C263.2 C266.1 C270.1 C291.2 C292.2 C299.1 C300.1 C324.2 C331.2 C332.1 C341.1 C350.2 C359.2 C361.1 C362.1 C416.2 C417.2 C419.1 C420.1 C431.2 C432.1 C434.2 C435.2 C436.1 C437.1 C460.2 C461.2 C462.1 C489.1 C490.2 C519.2 C524.1
2.5V_ENABLE: J112.2 R299.1 U1.1
2.5V_GX_IO: C235.1 C271.1 C279.1 C284.1 C288.1 C316.1 C319.1 C346.1 C696.1 C784.1
2.5V_OUT: C14.2 C15.2 R4.1 U1.4
2.5V_REG_IN: C9.1 R2.1 R299.2 U1.2
3.3V: C51.1 C53.1 C58.1 C59.1 C62.1 C63.1 C64.1 C65.1 C66.2 C67.2 C68.2 C69.2 C70.1 C71.1 C72.1 C74.1 C75.1 C78.1 C79.1 C80.1 C93.1 C423.1 C424.1 C496.1 C497.1 C646.1 C652.1 C655.1 C660.1 C662.1 C665.1 C666.1 C669.1 C670.1 C671.1 C673.1 C674.1 C682.1 C749.1 C750.1 C751.1 C752.1 C753.1 J63.4 J78.5 J78.7 J85.4 J85.6 J87.4 J87.6 PMCJN1.12 PMCJN1.19 PMCJN1.31 PMCJN1.41 PMCJN1.45 PMCJN1.57(V4_IO) PMCJN2.12 PMCJN2.15 PMCJN2.24 PMCJN2.27 PMCJN2.36 PMCJN2.41 PMCJN2.50 PMCJN2.53 PMCJN2.62 R37.2 R41.2 R42.2 R44.2 R51.2 R55.2 R57.2 R65.2 R66.2 R67.2 R68.2 R80.2 R81.2 R82.2 R83.2 R84.2 R85.2 R98.2 R99.2 R100.2 R119.2 R123.2 R124.1 R133.2 R134.2 R140.1 R142.2 R143.2 R144.2 R145.2 R146.2 R147.2 R148.2 R158.2 R160.2 R161.1 R162.1 R173.1 R174.1 R175.2 R204.1 R205.1 R206.1 R209.1 R210.1 R211.1 R217.1 R218.1 R219.1 R220.1 R221.1 R224.1 R226.1 R227.1 R228.1 R229.1 R230.1 R231.2 R232.2 R233.2 R235.1 R237.1 R239.1 R241.1 R278.1 R279.2 R280.2 R281.2 R289.2 R290.2 R291.2 R292.2 R293.2 R294.2 R303.2 R304.2 R305.2 R358.1 R359.1 R360.1 RN14.1 RN14.2 RN14.3 RN14.4 RN14.5 RN14.6 RN14.7 RN14.8 RN37.1 RN37.2 RN37.3 RN37.4 RN37.5 RN37.6 RN37.7 RN37.8 RN38.1 RN38.2 RN38.3 RN38.4 RN38.5 RN38.6 RN38.7 RN38.8 RN39.1 RN39.2 U19.30 U19.40(VCC2) U20.30 U20.40(VCC2) U21.30 U21.40(VCC2) U25.7 U25.18 U25.31 U25.42(VCC4) U26.7 U26.18 U26.31 U26.42(VCC4) U29.5 U29.12 U29.22 U29.40 U29.43 U29.45(WP*) U29.59 U29.61 U29.67 U29.68 U29.92 U30.5 U30.12 U30.22 U30.40 U30.43 U30.45(WP*) U30.59 U30.61 U30.67 U30.68 U30.92 U31.37 U34.7 U34.18 U34.31 U34.42(VCC4) U43.16 U44.16
3.3V_CLK1: C518.1 C684.1 C685.1 C686.1 C747.1 R15.1 R87.1 R90.1 R172.2 R195.1 U32.2 U32.8 U32.10 U32.18(VDD2) U46.8 Y3.4(VCC)
3.3V_CLK2: C532.1 C687.1 C721.1 C722.1 C748.1 R91.1 R94.1 R159.2 R192.1 R193.1 U18.2 U18.8 U18.10 U18.18(VDD2) U47.8 Y2.4(VCC)
3.3V_CLK3: C526.1 C643.1 C694.1 C695.1 R260.2 U13.1(VDDO) U13.2 Y1.4(VCC)
3.3V_DIV: C661.2 C663.2 C664.2 C692.1 C693.1 R19.2 R28.2 R31.2 R355.2 U4.8 U6.1 U6.8 U6.20
3.3V_ENABLE: J111.2 R296.1 U42.1
3.3V_EXT_CLK: C421.1 C422.1 C426.1 C429.1 C653.1 C745.1 R74.1 R75.1 U10.2 U10.9 U10.13 U10.17(VDDC3) U10.18 U10.22 U10.25 U10.29
3.3V_FAN_OUT: C73.1 U37.4 U37.5
3.3V_GX_IO: C54.1 C55.1 C56.1 C278.2 C281.1 C283.1 C301.1 C304.1 C309.1 C310.2 C315.1 C318.2 C333.1 C334.1 C336.2 C337.1 C340.2 C345.2 C347.1 C351.1 C353.2 C367.1 C368.2 C369.1 C376.1 C377.1 C380.1 C382.1 C383.1 C388.1 C389.1 C390.1 C394.1 C404.1 C405.1 C406.1 C407.1 C408.1 C414.1 C415.1 C683.1 C783.1
3.3V_GX_XCVR_AND_CLOCKS: C680.1 R297.2 U42.4
3.3V_LAN: C83.1 C667.1 C668.1 C672.1 C690.1 C691.1 R121.2 R243.2 R244.2 RJ1.9 RJ1.11 U11.1 U11.11 U11.16 U11.33 U11.44 U11.62 U11.77 U11.98 U11.110 U11.120 Y4.6(VCC)
3.3V_PLL: C84.1 C85.1 C89.1 C91.1 U15.AB17 U15.AE17 U15.H17 U15.L17
3.3V_PS: C57.1 C357.1 C358.1
3.3V_REF: C398.1 R187.1 R222.2 U37.16 U38.3(OUT)
3.3V_RS232: C495.1 C540.1 R163.1 R164.1 R169.1 R170.1 U28.16(VCC) U33.16(VCC)
3.3V_S_IO: C467.1 C468.1 C473.1 C478.1 C479.1 C482.1 C485.1 C486.1 C502.1 C505.1 C506.1 C509.1 C510.1 C522.1 C531.1 C535.1 C543.1 C551.1 C553.1 C555.1 C572.1 C575.1 C578.1 C582.1 C589.1 C590.1 C595.1 C598.1 C601.1 C607.1 C612.1 C613.1 C681.1 C782.1 R131.2 U15.A3 U15.A12 U15.A21 U15.A30 U15.AA1 U15.AA32 U15.AC16 U15.AC17 U15.AK1 U15.AK2 U15.AK31 U15.AK32 U15.AM3 U15.AM12 U15.AM21 U15.AM30 U15.C1 U15.C2 U15.C31 U15.C32 U15.K16 U15.K17 U15.M1 U15.M32 U15.T10 U15.T23 U15.U10 U15.U23
3.3V_S_IOB: C728.1
3.3V_TEL: R351.1 U8.4
3.3V_XCVR_CLKS: C41.1 C43.1 C44.1 C209.1 C210.1 C236.1 C240.1 C244.1 C701.1
3.3V_XPAK: C16.1 C689.1 U27.5 U27.6 U27.30 U27.31
3.3VIO_ENABLE: C317.1 J114.2 U37.2
