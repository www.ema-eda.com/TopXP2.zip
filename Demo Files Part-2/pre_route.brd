# Allegro board pre_route.brd (continued)
## Nets (continued)
3.3VM: C122.1 C123.1 C145.1 C146.1 R2.2 U2.3
3.3VM_ATX: J31.1 J31.2 J31.11
5V_CF: C711.1 C712.1 C713.1 C774.2 CON3.13 CON3.38 U59.2 U59.3(VOUT2)
5V_TEL: U8.7
5V_XPAK: C13.1 C688.1 U27.4 U27.32
5VM: C120.1 C121.1 C170.1 C254.1 C293.1 C294.1 C325.1 C339.1 C344.1 C392.1 C678.1 C679.1 PMCJN1.8 PMCJN1.18 PMCJN1.30 PMCJN1.38 PMCJN1.50 PMCJN1.62 R189.1 R215.1 R296.2 R318.1 R319.1 R344.1 R352.1 U42.2 U59.4
5VM_ATX: J31.4 J31.6 J31.19 J31.20
12V_DIV: C776.1 R354.2 U60.5(OUT)
12V_TEL: U45.7 U45.8
12VM: C76.1 C110.1 C131.1 J78.1 PMCJN2.1 R300.1 R301.1 R361.2
12VM_ATX: J31.10
-12VM: C26.1 C27.1 C61.1 J31.12 PMCJN1.2
-48V_IN: C48.2
-48V_ONN: ISO1.8 U8.2 U45.2
-48V_PWR: C100.2 C124.2 ISO1.2 ISO1.7 R216.1 U8.3(VIN_ORBR_-_CRBR_) U45.3(VIN_ORBR_-_CRBR_)
GND: C9.2 C12.2 C13.2 C14.1 C15.1 C16.2 C26.2 C27.2 C28.2 C34.1 C36.1 C37.1 C38.2 C39.2 C40.2 C42.2 C49.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.1 C67.1 C68.1 C69.1 C70.2 C71.2 C73.2 C74.2 C75.2 C76.2 C78.2 C79.2 C81.2 C82.2 C86.2 C87.2 C88.2 C90.2 C93.2 C95.2 C102.2 C103.1 C110.2 C111.2 C114.2 C116.2 C119.2 C120.2 C121.2 C122.2 C123.2 C126.2 C128.2 C129.2 C130.1 C131.2 C132.2 C133.2 C134.2 C135.1 C140.2 C141.1 C142.1 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.1 C150.1 C151.1 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.1 C169.2 C170.2 C171.2 C172.2 C173.1 C174.1 C175.1 C176.1 C177.1 C178.1 C179.1 C180.1 C181.1 C182.1 C183.1 C184.1 C185.1 C186.1 C187.1 C188.1 C189.1 C190.1 C191.1 C192.1 C193.1 C194.1 C195.1 C196.2 C197.2 C198.2 C199.1 C200.2 C201.2 C202.2 C203.2 C208.1 C211.1 C212.1 C213.1 C214.2 C215.2 C216.2 C217.1 C218.2 C219.1 C220.2 C226.2 C227.1 C228.2 C232.2 C233.2 C234.2 C235.2 C237.1 C238.2 C239.2 C241.2 C242.2 C245.2 C246.2 C247.1 C248.2 C250.2 C251.2 C253.2 C254.2 C255.2 C256.1 C257.2 C258.2 C259.1 C260.2 C261.1 C262.2 C263.1 C264.2 C265.2 C266.2 C267.1 C268.2 C269.2 C270.2 C271.2 C272.2 C273.2 C274.1 C275.1 C276.2 C277.1 C278.1 C279.2 C280.2 C281.2 C283.2 C284.2 C285.1 C288.2 C289.1 C291.1 C292.1 C293.2 C294.2 C296.1 C298.2 C299.2 C300.2 C301.2 C302.2 C304.2 C305.1 C306.1 C307.2 C308.2 C309.2 C310.1 C311.2 C312.2 C313.2 C315.2 C316.2 C317.2 C318.1 C319.2 C320.1 C321.2 C323.1 C324.1 C325.2 C327.1 C328.2 C330.1 C331.1 C332.2 C333.2 C334.2 C335.1 C336.1 C337.2 C338.1 C339.2 C340.1 C341.2 C342.1 C343.1 C344.2 C345.1 C346.2 C347.2 C348.1 C349.1 C350.1 C351.2 C353.1 C354.1 C356.1 C357.2 C358.2 C359.1 C361.2 C362.2 C367.2 C368.1 C369.2 C376.2 C377.2 C380.2 C382.2 C383.2 C388.2 C389.2 C390.2 C391.1 C392.2 C393.2 C394.2 C395.2 C396.1 C397.2 C398.2 C404.2 C405.2 C406.2 C407.2 C408.2 C414.2 C415.2 C416.1 C417.1 C418.1 C419.2 C420.2 C423.2 C424.2 C425.2 C431.1 C432.2 C434.1 C435.1 C436.2 C437.2 C439.2 C440.2 C441.1 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C449.1 C450.1 C451.1 C452.2 C453.2 C454.1 C455.1 C456.1 C457.2 C458.2 C460.1 C461.1 C462.2 C465.1 C466.1 C467.2 C468.2 C471.1 C472.1 C473.2 C474.1 C475.1 C476.1 C477.1 C478.2 C479.2 C482.2 C483.1 C484.1 C485.2 C486.2 C487.1 C488.1 C489.2 C490.1 C491.1 C492.2 C494.1 C495.2 C496.2 C497.2 C498.2 C499.1 C500.2 C501.1 C502.2 C503.2 C504.2 C505.2 C506.2 C507.1 C508.1 C509.2 C510.2 C511.2 C512.1 C513.2 C514.1 C515.1 C516.1 C517.2 C519.1 C520.2 C521.1 C522.2 C523.2 C524.2 C525.1 C527.1 C528.1 C529.2 C530.2 C531.2 C534.2 C535.2 C536.1 C538.2 C539.1 C540.2 C542.2 C543.2 C545.1 C546.1 C547.1 C548.2 C549.2 C550.2 C551.2 C552.1 C553.2 C554.2 C555.2 C556.2 C557.2 C558.2 C560.2 C561.2 C562.2 C563.2 C564.2 C565.1 C566.1 C567.2 C568.2 C569.2 C570.2 C571.1 C572.2 C573.2 C574.1 C575.2 C576.2 C577.2 C578.2 C579.1 C580.2 C581.2 C582.2 C583.2 C584.1 C585.2 C587.1 C588.2 C589.2 C590.2 C591.2 C592.2 C595.2 C596.2 C597.2 C598.2 C599.1 C600.1 C601.2 C605.2 C606.1 C607.2 C608.1 C609.1 C612.2 C613.2 C614.2 C615.1 C617.1 C618.2 C619.2 C620.2 C621.1 C622.1 C623.2 C624.2 C625.2 C626.2 C628.1 C629.2 C630.2 C631.2 C632.2 C633.1 C634.2 C635.2 C636.2 C637.2 C638.2 C639.1 C640.2 C641.1 C642.2 C644.2 C645.2 C646.2 C647.2 C648.2 C649.2 C650.2 C651.2 C652.2 C654.2 C655.2 C656.2 C657.2 C658.2 C667.2 C668.2 C669.2 C670.2 C671.2 C672.2 C673.2 C674.2 C678.2 C679.2 C681.2 C682.2 C683.2 C688.2 C689.2 C690.2 C691.2 C696.2 C697.2 C700.2 C706.2 C711.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C722.2 C725.1 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C746.2 C749.2 C750.2 C751.2 C752.2 C753.2 C775.1 C776.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C790.2 CN1.5(2) CN1.6 CN1.7 CN1.8 CN2.5(2) CN2.6 CN2.7 CN2.8 CN3.5(2) CN3.6 CN3.7 CN3.8 CN4.5(2) CN4.6 CN4.7 CN4.8 CN5.5(2) CN5.6 CN5.7 CN5.8 CN6.5(2) CN6.6 CN6.7 CN6.8 CN7.5(2) CN7.6 CN7.7 CN7.8 CN8.5(2) CN8.6 CN8.7 CN8.8 CN9.5(2) CN9.6 CN9.7 CN9.8 CN10.5(2) CN10.6 CN10.7 CN10.8 CN11.5(2) CN11.6 CN11.7 CN11.8 CN12.5(2) CN12.6 CN12.7 CN12.8 CN13.5(2) CN13.6 CN13.7 CN13.8 CON3.1 CON3.25 CON3.33 CON3.39 CON3.50 HS1.1(HS1) J31.3 J31.7 J31.9 J31.13 J31.15 J31.16 J31.17 J34.39 J34.40 J34.41 J34.42 J34.43 J36.2 J36.4 J36.6 J36.8 J42.A2(GND9) J42.A5 J42.A8 J42.A11 J42.A14 J42.B2 J42.B5 J42.B8 J42.B11 J48.1 J55.1 J56.1 J57.A3 J57.A6 J57.A9 J57.A12 J57.A14 J57.A17 J57.A20 J57.A23 J57.A26 J57.B3 J57.B6 J57.B9 J57.B12 J57.B14 J57.B17 J57.B20 J57.B23 J57.B26 J58.A3 J58.A6 J58.A9 J58.A12 J58.A14 J58.A17 J58.A20 J58.A23 J58.A26 J58.B3 J58.B6 J58.B9 J58.B12 J58.B14 J58.B17 J58.B20 J58.B23 J58.B26 J59.A2(GND9) J59.A5 J59.A8 J59.A11 J59.A14 J59.B2 J59.B5 J59.B8 J59.B11 J63.2 J63.10 J75.39 J75.40 J75.41 J75.42 J75.43 J78.2 J78.4 J78.6 J78.8 J78.10 J78.12 J78.14 J78.16 J78.18 J78.20 J79.1 J85.2 J85.10 J87.2 J87.10 J90.1 J92.2 J92.19 J92.22 J92.24 J92.26 J92.30 J92.34 J92.40 J111.1 J112.1 J113.1 J114.1 J124.5 J124.14 J124.19 J124.20 J124.21 J124.22 PMCJN1.3 PMCJN1.11 PMCJN1.14 PMCJN1.15 PMCJN1.24 PMCJN1.25 PMCJN1.34 PMCJN1.35 PMCJN1.39 PMCJN1.44 PMCJN1.51 PMCJN1.56 PMCJN1.63 PMCJN2.6 PMCJN2.7 PMCJN2.18 PMCJN2.21 PMCJN2.30 PMCJN2.33 PMCJN2.37 PMCJN2.40 PMCJN2.44 PMCJN2.56 PMCJN2.59 PMCJN2.63 R3.1 R39.2 R53.2 R56.2 R76.1 R77.1 R102.2 R105.1 R106.1 R107.1 R108.1 R109.1 R110.1 R111.1 R112.1 R113.1 R114.1 R120.2 R125.2 R128.2 R129.1 R130.2 R132.2 R139.2 R141.2 R185.2 R223.1 R225.1 R242.2 R259.2 R262.1 R263.1 R264.1 R265.1 R266.1 R267.1 R268.1 R269.1 R282.1 R283.1 R284.1 R285.1 R286.2 R306.2 R307.2 R329.1 R338.1 R339.1 R340.1 R341.1 R350.1 R353.2 R357.2 RN15.1 RN15.2 RN15.3 RN15.4 RN15.5 RN15.6 RN15.7 RN15.8 RN16.1 RN16.2 RN16.3 RN16.4 RN16.5 RN16.6 RN16.7 RN16.8 RN17.1 RN17.2 RN17.3 RN17.4 RN17.5 RN17.6 RN17.7 RN17.8 RN18.1 RN18.2 RN18.3 RN18.4 RN18.5 RN18.6 RN18.7 RN18.8 RN19.1 RN19.2 RN19.3 RN19.4 RN19.5 RN19.6 RN19.7 RN19.8 RN20.3 RN20.4 RN20.5 RN20.6 RN20.7 U1.3 U1.6(TAB) U5.2 U5.6 U5.7 U5.8 U5.10 U7.A2 U7.A13 U7.A20 U7.A31 U7.AA14 U7.AA19 U7.AA21 U7.AB22 U7.AC5 U7.AC28 U7.AF9 U7.AF17 U7.AG6 U7.AH10 U7.AH23 U7.AH27 U7.AL1 U7.AL32 U7.AM2 U7.AM13 U7.AM20 U7.AM31 U7.B1 U7.B32 U7.E10 U7.E23 U7.F7 U7.F27 U7.G17 U7.J24 U7.K5 U7.K28 U7.L11 U7.M12 U7.M14 U7.M19 U7.N1 U7.N14 U7.N16 U7.N18 U7.N20 U7.N32 U7.P12 U7.P13 U7.P15 U7.P17 U7.P19 U7.P21 U7.R14 U7.R16 U7.R18 U7.R20 U7.T7 U7.T13 U7.T15 U7.T17 U7.T19 U7.U14 U7.U16 U7.U18 U7.U20 U7.V11 U7.V13 U7.V15 U7.V17 U7.V19 U7.V22 U7.V27 U7.W12 U7.W14 U7.W16 U7.W18 U7.W20 U7.Y1 U7.Y13 U7.Y15 U7.Y17 U7.Y19 U7.Y32 U8.5 U11.13 U11.19 U11.24 U11.39 U11.52 U11.57 U11.67 U11.72 U11.93 U11.103 U11.108 U11.117 U12.2 U12.6 U12.7 U12.8 U12.10 U14.1 U14.4 U14.7(PGND) U15.A2 U15.A10 U15.A23 U15.A31 U15.AA10 U15.AA16 U15.AA17 U15.AA23 U15.AB8 U15.AB25 U15.AC1 U15.AC32 U15.AD17 U15.AF17 U15.AG6 U15.AG27 U15.AH6 U15.AH8 U15.AH10 U15.AH12 U15.AH21 U15.AH23 U15.AH25 U15.AH27(VREF5B8) U15.AL1 U15.AL2 U15.AL31 U15.AL32 U15.AM2 U15.AM10 U15.AM23 U15.AM31 U15.B1 U15.B2 U15.B31 U15.B32 U15.E6 U15.E8 U15.E10 U15.E12 U15.E21 U15.E23 U15.E25 U15.E27 U15.F6 U15.F27 U15.H18 U15.H24 U15.J17 U15.K1 U15.K32 U15.L8 U15.L25 U15.M13 U15.M15 U15.M16 U15.M17 U15.M18 U15.M20 U15.N12 U15.N14 U15.N16 U15.N17 U15.N19 U15.N21 U15.P13 U15.P15 U15.P18 U15.P20 U15.R12 U15.R14 U15.R16 U15.R17 U15.R19 U15.R21 U15.T12 U15.T13 U15.T15 U15.T18 U15.T20 U15.T21 U15.U12 U15.U13 U15.U15 U15.U18 U15.U20 U15.U21 U15.V12 U15.V14 U15.V16 U15.V17 U15.V19 U15.V21 U15.W13 U15.W15 U15.W18 U15.W20 U15.Y14 U15.Y16 U15.Y17 U15.Y19 U17.3 U19.10 U19.20 U20.10 U20.15 U20.16 U20.20 U21.10 U21.20 U22.12 U23.12 U24.12 U25.4 U25.10 U25.15 U25.21 U25.28 U25.34 U25.39 U25.45 U26.4 U26.10 U26.15 U26.21 U26.28 U26.34 U26.39 U26.45 U28.15 U29.2 U29.41 U29.58 U29.69 U29.70 U29.71 U29.79 U30.2 U30.41 U30.58 U30.69 U30.70 U30.71 U30.79 U31.27 U31.46 U33.15 U34.4 U34.10 U34.15 U34.21 U34.26 U34.28 U34.34 U34.39 U34.45 U36.8 U36.10 U36.11 U36.14 U36.15 U36.17 U36.18 U36.19 U37.8 U37.10 U37.11 U37.14 U37.15 U37.17 U37.18 U37.19 U38.5 U38.6 U38.7 U38.8 U39.12 U43.8(VSS) U44.8(VSS) U45.4 U45.5 U52.12 U53.2 U60.2 XU2.2 XU2.5 XU2.8 XU2.11 XU2.14 XU2.17 XU2.20 XU2.23 XU2.26 XU2.29 XU2.32 XU2.35 XU2.38 XU2.41 XU2.44 XU2.47 XU2.50 XU2.65 XU2.66 XU2.79 XU2.82 XU2.85 XU2.88 XU2.91 XU2.94 XU2.97 XU2.100 XU2.101 XU2.103 XU2.106 XU2.109 XU2.112 XU2.115 XU2.118 XU2.121 XU2.124 XU2.127 XU2.130 XU2.133 XU2.136 XU2.139 XU2.142 XU2.145 XU2.148 XU2.151 XU2.154 XU2.157 XU2.160 XU2.163 XU2.166 XU2.169 XU2.198 XU2.201 XU2.204 XU2.207 XU2.210 XU2.213 XU2.216 XU2.219 XU2.222 XU2.225 XU2.228 XU2.231 XU2.234 XU2.237 XU2.239 XU2.240 Y4.3
GND_HSSI: C19.2 C33.2 C35.1 C41.2 C43.2 C44.2 C50.2 C51.2 C52.2 C53.2 C60.2 C72.2 C77.2 C80.2 C136.1 C137.2 C138.1 C139.1 C204.1 C205.1 C206.1 C207.1 C209.2 C210.2 C229.2 C230.1 C231.1 C236.2 C240.2 C243.2 C244.2 C249.2 C252.2 C282.2 C286.1 C290.1 C297.2 C303.2 C322.1 C326.2 C352.2 C355.1 C360.2 C363.2 C372.2 C373.2 C384.2 C387.1 C399.2 C402.2 C403.1 C421.2 C422.2 C426.2 C427.2 C428.2 C429.2 C430.2 C433.2 C464.2 C493.2 C518.2 C526.2 C532.2 C643.2 C653.2 C659.1 C660.2 C661.1 C662.2 C663.1 C664.1 C665.2 C666.2 C680.2 C684.2 C685.2 C686.2 C687.2 C692.2 C693.2 C694.2 C695.2 C699.2 C701.2 C721.2 C747.2 C748.2 C754.1 C755.1 C756.1 C757.1 C758.1 C759.1 C760.1 C761.1 C762.1 C763.1 C764.1 C765.1 C766.1 C767.1 C768.1 C769.1 C770.1 C771.1 C772.1 C773.1 C777.2 C778.1 C779.1 C780.1 C781.1 C788.2 C789.2 J1.1BG J1.1DG J1.1FG J1.1HG J1.2BG J1.2DG J1.2FG J1.2HG J1.3BG J1.3DG J1.3FG J1.3HG J1.4BG J1.4DG J1.4FG J1.4HG J1.5BG J1.5DG J1.5FG J1.5HG J1.6BG J1.6DG J1.6FG J1.6HG J1.7BG J1.7DG J1.7FG J1.7HG J1.8BG J1.8DG J1.8FG J1.8HG J1.9BG J1.9DG J1.9FG J1.9HG J1.10BG J1.10DG J1.10FG J1.10HG J2.2 J2.3 J2.4 J2.5 J3.2 J3.3 J3.4 J3.5 J4.2 J4.3 J4.5 J5.2 J5.3 J5.4 J5.5 J6.2 J6.3 J6.4 J6.5 J11.1 J11.4 J11.7 J11.8 J11.9 J11.10 J11.11 J11.12 J11.13 J15.1 J15.4 J15.7 J15.8 J15.9 J15.10 J15.11 J15.12 J15.13 J16.2 J16.3 J16.4 J16.5 J17.2 J17.3 J17.4 J17.5 J18.2 J18.3 J18.4 J18.5 J19.2 J19.3 J19.4 J19.5 J20.2 J20.3 J20.4 J20.5 J23.1 J23.4 J23.7 J23.8 J23.9 J23.10 J23.11 J23.12 J23.13 J24.2 J24.3 J24.4 J24.5 J25.2 J25.3 J25.4 J25.5 J26.2 J26.3 J26.4 J26.5 J27.2 J27.3 J27.4 J27.5 J28.2 J28.3 J28.4 J28.5 J29.2 J29.3 J29.4 J29.5 J30.2 J30.3 J30.4 J30.5 J32.1 J32.4 J32.7 J32.8 J32.9 J32.10 J32.11 J32.12 J32.13 J37.2 J37.3 J37.4 J37.5 J38.1 J38.9 J38.10 J38.11 J38.14 J38.17 J38.20(VEET3) J38.21 J38.22 J38.23 J38.24 J38.25 J38.26 J38.27 J38.28 J38.29 J38.30 J38.31 J38.32 J38.33 J38.34 J38.35 J38.36 J38.37 J38.38 J38.39 J38.40 J43.2 J43.3 J43.4 J43.5 J45.1 J45.9 J45.10 J45.11 J45.14 J45.17 J45.20(VEET3) J45.21 J45.22 J45.23 J45.24 J45.25 J45.26 J45.27 J45.28 J45.29 J45.30 J45.31 J45.32 J45.33 J45.34 J45.35 J45.36 J45.37 J45.38 J45.39 J45.40 J46.2 J46.3 J46.4 J46.5 J47.2 J47.3 J47.4 J47.5 J49.2 J49.3 J49.4 J49.5 J52.2 J52.3 J52.4 J52.5 J54.1 J54.9 J54.10 J54.11 J54.14 J54.17 J54.20(VEET3) J54.21 J54.22 J54.23 J54.24 J54.25 J54.26 J54.27 J54.28 J54.29 J54.30 J54.31 J54.32 J54.33 J54.34 J54.35 J54.36 J54.37 J54.38 J54.39 J54.40 J60.2 J60.3 J60.4 J60.5 J61.2 J61.3 J61.4 J61.5 J62.2 J62.3 J62.4 J62.5 J64.1 J64.9 J64.10 J64.11 J64.14 J64.17 J64.20(VEET3) J64.21 J64.22 J64.23 J64.24 J64.25 J64.26 J64.27 J64.28 J64.29 J64.30 J64.31 J64.32 J64.33 J64.34 J64.35 J64.36 J64.37 J64.38 J64.39 J64.40 J69.2 J69.3 J69.4 J69.5 J72.2 J72.3 J72.4 J72.5 J72.6 J72.7 J72.8 J72.9 J72.10 J72.11 J72.12 J72.13 J72.14 J72.15 J72.16 J72.17 J72.18 J72.19 J72.20 J72.21 J72.22 J72.23 J72.24 J72.25 J72.26 J72.27 J72.28 J72.29 J72.30 J72.31 J72.32 J72.33 J72.34 J72.35 J76.2 J76.3 J76.4 J76.5 J77.2 J77.3 J77.4 J77.5 J77.6 J77.7 J77.8 J77.9 J77.10 J77.11 J77.12 J77.13 J77.14 J77.15 J77.16 J77.17 J77.18 J77.19 J77.20 J77.21 J77.22 J77.23 J77.24 J77.25 J77.26 J77.27 J77.28 J77.29 J77.30 J77.31 J77.32 J77.33 J77.34 J77.35 J80.2 J80.3 J80.4 J80.5 J81.2 J81.3 J81.4 J81.5 J81.6 J81.7 J81.8 J81.9 J81.10 J81.11 J81.12 J81.13 J81.14 J81.15 J81.16 J81.17 J81.18 J81.19 J81.20 J81.21 J81.22 J81.23 J81.24 J81.25 J81.26 J81.27 J81.28 J81.29 J81.30 J81.31 J81.32 J81.33 J81.34 J81.35 J83.2 J83.3 J83.4 J83.5 J84.2 J84.3 J84.4 J84.5 J86.2 J86.3 J86.4 J86.5 J86.6 J86.7 J86.8 J86.9 J86.10 J86.11 J86.12 J86.13 J86.14 J86.15 J86.16 J86.17 J86.18 J86.19 J86.20 J86.21 J86.22 J86.23 J86.24 J86.25 J86.26 J86.27 J86.28 J86.29 J86.30 J86.31 J86.32 J86.33 J86.34 J86.35 J88.2 J88.3 J88.4 J88.5 J89.2 J89.3 J89.4 J89.5 J91.2 J91.3 J91.4 J91.5 J93.2 J93.3 J93.4 J93.5 J93.6 J93.7 J93.8 J93.9 J93.10 J93.11 J93.12 J93.13 J93.14 J93.15 J93.16 J93.17 J93.18 J93.19 J93.20 J93.21 J93.22 J93.23 J93.24 J93.25 J93.26 J93.27 J93.28 J93.29 J93.30 J93.31 J93.32 J93.33 J93.34 J93.35 J94.2 J94.3 J94.4 J94.5 J95.2 J95.3 J95.4 J95.5 J97.2 J97.3 J97.4 J97.5 J98.2 J98.3 J98.4 J98.5 J98.6 J98.7 J98.8 J98.9 J98.10 J98.11 J98.12 J98.13 J98.14 J98.15 J98.16 J98.17 J98.18 J98.19 J98.20 J98.21 J98.22 J98.23 J98.24 J98.25 J98.26 J98.27 J98.28 J98.29 J98.30 J98.31 J98.32 J98.33 J98.34 J98.35 J99.2 J99.3 J99.4 J99.5 J100.2 J100.3 J100.4 J100.5 J101.2 J101.3 J101.4 J101.5 J101.6 J101.7 J101.8 J101.9 J101.10 J101.11 J101.12 J101.13 J101.14 J101.15 J101.16 J101.17 J101.18 J101.19 J101.20 J101.21 J101.22 J101.23 J101.24 J101.25 J101.26 J101.27 J101.28 J101.29 J101.30 J101.31 J101.32 J101.33 J101.34 J101.35 J102.2 J102.3 J102.4 J102.5 J103.2 J103.3 J103.4 J103.5 J104.2 J104.3 J104.4 J104.5 J105.2 J105.3 J105.4 J105.5 J105.6 J105.7 J105.8 J105.9 J105.10 J105.11 J105.12 J105.13 J105.14 J105.15 J105.16 J105.17 J105.18 J105.19 J105.20 J105.21 J105.22 J105.23 J105.24 J105.25 J105.26 J105.27 J105.28 J105.29 J105.30 J105.31 J105.32 J105.33 J105.34 J105.35 J106.2 J106.3 J106.4 J106.5 J107.2 J107.3 J107.4 J107.5 J108.1DG J108.1FG J108.1HG J108.2BG J108.2DG J108.2FG J108.2HG J108.3BG J108.3DG J108.3FG J108.3HG J108.4BG J108.4DG J108.4FG J108.4HG J108.5BG J108.5DG J108.5FG J108.5HG J108.6BG J108.6DG J108.6FG J108.6HG J108.7BG J108.7DG J108.7FG J108.7HG J108.8BG J108.8DG J108.8FG J108.8HG J108.9BG J108.9DG J108.9FG J108.9HG J108.10BG J108.10DG J108.10FG J108.10HG J109.1BG J109.1DG J109.1FG J109.1HG J109.2BG J109.2DG J109.2FG J109.2HG J109.3BG J109.3DG J109.3FG J109.3HG J109.4BG J109.4DG J109.4FG J109.4HG J109.5BG J109.5DG J109.5FG J109.5HG J109.6BG J109.6DG J109.6FG J109.6HG J109.7BG J109.7DG J109.7FG J109.7HG J109.8BG J109.8DG J109.8FG J109.8HG J109.9BG J109.9DG J109.9FG J109.9HG J109.10BG J109.10DG J109.10FG J109.10HG J121.2 J121.3 J121.4 J121.5 J122.2 J122.3 J122.4 J122.5 J123.3 J123.4 R5.1 R16.1 R17.1 R21.1 R27.1 R32.1 R34.1 R35.1 R40.1 R46.1 R47.1 R48.2 R88.1 R89.1 R92.1 R93.1 R176.1 R177.1 R191.1 R194.1 R196.2 R298.1 R348.1 U4.5 U6.11 U9.5 U10.7 U10.8 U10.11 U10.15 U10.20 U10.24 U10.27 U10.31 U13.4 U18.1 U18.9 U18.13 U27.1 U27.2 U27.3 U27.33 U27.34 U27.35 U27.36 U27.37 U27.40 U27.43 U27.46 U27.49 U27.52 U27.53 U27.54 U27.57 U27.60 U27.63 U27.66 U27.69 U27.70 U32.1 U32.9 U32.13 U42.3 U42.6(TAB) U46.5(VSS) U47.5(VSS) Y1.2 Y2.2 Y3.2
GND_PLL: C45.2 C46.2 C47.2 C84.2 C85.2 C89.2 C91.2 C287.1 C295.1 C314.2 C329.2 C364.2 C365.2 C366.2 C370.1 C371.1 C374.2 C375.1 C378.2 C379.1 C381.2 C385.2 C386.1 C400.2 C401.2 C409.1 C410.2 C411.2 C412.2 C413.2 C438.2 C459.2 C463.2 C469.2 C470.1 C480.1 C481.2 C533.2 C537.1 C541.1 C544.2 C559.2 C586.2 C593.1 C594.1 C602.2 C603.1 C604.1 C610.2 C611.2 C616.2 C627.2 C698.2 U15.A15 U15.AB4 U15.AB5 U15.AB16 U15.AB28 U15.AB29 U15.AE16 U15.AH3 U15.AH16 U15.AH17 U15.AH30 U15.AJ1 U15.AJ15 U15.AJ19 U15.AJ32 U15.AK15 U15.AL15 U15.AL17 U15.AL19 U15.AM15 U15.AM17 U15.AM19 U15.B19 U15.C15 U15.C17 U15.D1 U15.D15 U15.D17 U15.D32 U15.E3 U15.E17 U15.E30 U15.F17 U15.H15 U15.L4 U15.L5 U15.L16 U15.L28 U15.L29 U15.T3 U15.T4 U15.T5 U15.T6 U15.T7 U15.T22 U15.T24 U15.T26 U15.U3 U15.U4 U15.U7 U15.U9 U15.U11 U15.U26 U15.U29 U15.U30 U15.U31 U15.U32
GND_RTN: C48.1 C100.1 C124.1 R207.2 U8.1 U45.1
GNDA_PLL1: U7.T25 U7.T26
GNDA_PLL2: U7.U25 U7.U26
GNDA_PLL3: U7.U8 U7.V8
GNDA_PLL4: U7.R8 U7.T8
GNDA_PLL5: U7.G16 U7.H16
GNDA_PLL6: U7.AD16 U7.AE16
GNDA_PLL7: U7.F26 U7.G26
GNDA_PLL8: U7.AG26 U7.AG27
GNDA_PLL9: U7.AF7 U7.AG7
GNDA_PLL10: U7.G7 U7.G8
GNDA_PLL11: U7.G18 U7.H18
GNDA_PLL12: U7.AD17 U7.AE17
V0_9: CN1.1 CN1.2 CN1.3 CN1.4 CN2.1 CN2.2 CN2.3 CN2.4 CN3.1 CN3.2 CN3.3 CN3.4 CN4.1 CN4.2 CN4.3 CN4.4 CN5.1 CN5.2 CN5.3 CN5.4 CN6.1 CN6.2 CN6.3 CN6.4 CN7.1 CN7.2 CN7.3 CN7.4 CN8.1 CN8.2 CN8.3 CN8.4 CN9.1 CN9.2 CN9.3 CN9.4 CN10.1 CN10.2 CN10.3 CN10.4 CN11.1 CN11.2 CN11.3 CN11.4 CN12.1 CN12.2 CN12.3 CN12.4 CN13.1 CN13.2 CN13.3 CN13.4 R7.2 R11.2 R23.2 R30.2 R70.2 R73.2 R136.1 R236.2 R238.2 RN5.9(2) RN5.10 RN5.11 RN5.12 RN5.13 RN5.14 RN5.15 RN5.16 RN23.1 RN23.2 RN23.3 RN23.4 RN23.5 RN23.6 RN23.7 RN23.8 RN24.1 RN24.2 RN24.3 RN24.4 RN24.5 RN24.6 RN24.7 RN24.8 RN25.1 RN25.2 RN25.3 RN25.4 RN25.5 RN25.6 RN25.7 RN25.8 RN26.1 RN26.2 RN26.3 RN26.4 RN26.5 RN26.6 RN26.7 RN26.8 RN27.10 RN27.11 RN27.12 RN27.13 RN27.14 RN27.15 RN27.16 RN28.1 RN28.2 RN28.3 RN28.4 RN28.5 RN28.6 RN28.7 RN28.8 RN29.9(2) RN29.10 RN29.11 RN29.12 RN29.13 RN29.14 RN29.15 RN29.16 RN30.1 RN30.2 RN30.3 RN30.4 RN30.5 RN30.6 RN30.7 RN30.8 RN31.1 RN31.2 RN31.3 RN31.4 RN31.5 RN31.6 RN31.7 RN31.8 RN32.1 RN32.2 RN32.3 RN32.4 RN32.5 RN32.6 RN32.7 RN32.8
VCCA: C87.1 C88.1 RJ1.2
VCCA_PLL1: U7.T24
VCCA_PLL2: U7.V26
VCCA_PLL3: U7.U9
VCCA_PLL4: U7.R9
VCCA_PLL5: U7.G15
VCCA_PLL6: U7.AE15
VCCA_PLL7: U7.H26
VCCA_PLL8: U7.AF26
VCCA_PLL9: U7.AE7
VCCA_PLL10: U7.H8
VCCA_PLL11: U7.H17
VCCA_PLL12: U7.AF18
VCCD_PLL1: U7.U24
VCCD_PLL2: U7.V25
VCCD_PLL3: U7.U7
VCCD_PLL4: U7.T9
VCCD_PLL5: U7.H15
VCCD_PLL6: U7.AD15
VCCD_PLL7: U7.H25
VCCD_PLL8: U7.AF25
VCCD_PLL9: U7.AE8
VCCD_PLL10: U7.H7
VCCD_PLL11: U7.J18
VCCD_PLL12: U7.AE18
VCCINT: U7.AA12 U7.AC10 U7.K10 U7.K23 U7.M21 U7.N13 U7.N15 U7.N17 U7.N19 U7.P14 U7.P16 U7.P18 U7.P20 U7.R13 U7.R15 U7.R17 U7.R19 U7.T14 U7.T16 U7.T18 U7.T20 U7.U13 U7.U15 U7.U17 U7.U19 U7.V14 U7.V16 U7.V18 U7.V20 U7.W13 U7.W15 U7.W17 U7.W19 U7.W21 U7.Y14 U7.Y16 U7.Y18 U7.Y20
VCCPD1: U7.V21 U7.Y21
VCCPD2: U7.N21 U7.R21
VCCPD3: U7.M18 U7.M20
VCCPD4: U7.M13 U7.M15
VCCPD5: U7.N12 U7.R12
VCCPD6: U7.V12 U7.Y12
VCCPD7: U7.AA13 U7.AA15
VCCPD8: U7.AA18 U7.AA20
VCCQP: C425.1 R300.2 U37.13
VDDQ: C720.1 R326.2 U53.5
APS: C564.1 C567.1
APS_INPUT: C86.1 C95.1 R115.1 R122.1 U14.5 U17.7 U17.8
APS_SENSE: R115.2 R247.1 U27.27
APS_SET: R248.1 U27.25
APS_XPAK: C12.1 C706.1 U27.7 U27.8 U27.28 U27.29
BRIDGE_RX_N<0>: J59.A3 U7.N31 U15.R5
BRIDGE_RX_N<1>: J59.B1 U7.N29 U15.G6
BRIDGE_RX_N<2>: J59.A6 U7.M32 U15.H8
BRIDGE_RX_N<3>: J59.B4 U7.M30 U15.H5
BRIDGE_RX_N<4>: J59.A9 U7.L32 U15.J7
BRIDGE_RX_N<5>: J59.B7 U7.L30 U15.J5
BRIDGE_RX_N<6>: J59.A12 U7.K32 U15.K8
BRIDGE_RX_N<7>: J59.B10 U7.K30 U15.K5
BRIDGE_RX_N<8>: U7.J32 U15.M6
BRIDGE_RX_N<9>: U7.H32 U15.M8
BRIDGE_RX_N<10>: U7.H30 U15.N10
BRIDGE_RX_N<11>: U7.G32 U15.N5
BRIDGE_RX_N<12>: U7.G30 U15.P9
BRIDGE_RX_N<13>: U7.F32 U15.N7
BRIDGE_RX_N<14>: U7.F30 U15.P6
BRIDGE_RX_N<15>: U7.E32 U15.R10
BRIDGE_RX_P<0>: J59.A1 U7.N30 U15.R6
BRIDGE_RX_P<1>: J59.B3 U7.N28 U15.G5
BRIDGE_RX_P<2>: J59.A4 U7.M31 U15.H7
BRIDGE_RX_P<3>: J59.B6 U7.M29 U15.H6
BRIDGE_RX_P<4>: J59.A7 U7.L31 U15.J8
BRIDGE_RX_P<5>: J59.B9 U7.L29 U15.J6
BRIDGE_RX_P<6>: J59.A10 U7.K31 U15.K7
BRIDGE_RX_P<7>: J59.B12 U7.K29 U15.K6
BRIDGE_RX_P<8>: U7.J31 U15.M7
BRIDGE_RX_P<9>: U7.H31 U15.M9
BRIDGE_RX_P<10>: U7.H29 U15.N9
BRIDGE_RX_P<11>: U7.G31 U15.N6
BRIDGE_RX_P<12>: U7.G29 U15.P10
BRIDGE_RX_P<13>: U7.F31 U15.N8
BRIDGE_RX_P<14>: U7.F29 U15.P5
BRIDGE_RX_P<15>: U7.E31 U15.R9
BRIDGE_RXCLK_N: J59.A15 R60.1 U15.L6
BRIDGE_RXCLK_P: J59.A13 R60.2 U15.L7
BRIDGE_TX_N<0>: J42.A3 U7.W29 U15.W2
BRIDGE_TX_N<1>: J42.B1 U7.W27 U15.W4
BRIDGE_TX_N<2>: J42.A6 U7.W25 U15.Y2
BRIDGE_TX_N<3>: J42.B4 U7.V29 U15.Y4
BRIDGE_TX_N<4>: J42.A9 U7.V24 U15.AA3
BRIDGE_TX_N<5>: J42.B7 U7.U28 U15.AB3
BRIDGE_TX_N<6>: J42.A12 U7.U23 U15.AA4
BRIDGE_TX_N<7>: J42.B10 U7.AE28 U15.AC2
BRIDGE_TX_N<8>: U7.AD27 U15.AD3
BRIDGE_TX_N<9>: U7.AD25 U15.AC3
BRIDGE_TX_N<10>: U7.AC27 U15.AE2
BRIDGE_TX_N<11>: U7.AC25 U15.AE4
BRIDGE_TX_N<12>: U7.AB26 U15.AF2
BRIDGE_TX_N<13>: U7.AB24 U15.AF4
BRIDGE_TX_N<14>: U7.AA27 U15.AG1
BRIDGE_TX_N<15>: U7.AA25 U15.AG4
BRIDGE_TX_P<0>: J42.A1 U7.W28 U15.W1
BRIDGE_TX_P<1>: J42.B3 U7.W26 U15.W3
BRIDGE_TX_P<2>: J42.A4 U7.W24 U15.Y1
BRIDGE_TX_P<3>: J42.B6 U7.V28 U15.Y3
BRIDGE_TX_P<4>: J42.A7 U7.V23 U15.AA2
BRIDGE_TX_P<5>: J42.B9 U7.U27 U15.AB2
BRIDGE_TX_P<6>: J42.A10 U7.U22 U15.AA5
BRIDGE_TX_P<7>: J42.B12 U7.AE27 U15.AB1
BRIDGE_TX_P<8>: U7.AD26 U15.AD4
BRIDGE_TX_P<9>: U7.AD24 U15.AC4
BRIDGE_TX_P<10>: U7.AC26 U15.AE1
BRIDGE_TX_P<11>: U7.AC24 U15.AE3
BRIDGE_TX_P<12>: U7.AB25 U15.AF1
BRIDGE_TX_P<13>: U7.AB23 U15.AF3
BRIDGE_TX_P<14>: U7.AA26 U15.AG2
BRIDGE_TX_P<15>: U7.AA24 U15.AG3
BRIDGE_TXCLK_N: J42.A15 R323.1 U7.AE26 U15.U1
BRIDGE_TXCLK_P: J42.A13 R323.2 U7.AE25 U15.U2
BST: C92.1 U14.10
BUS_CONV_5V: C102.1 C103.2 C587.2 C588.1 C639.2 C640.1 C641.2 C642.1 U22.24(VCC) U23.24(VCC) U24.24(VCC) U39.24(VCC) U52.24(VCC)
CE_S_N: U15.AF18
CEO_S_N: U15.AH15
CF_ATASEL_N: U15.H11 U52.6
CF_CS_N: U15.K12 U52.10
CF_POWER: U15.F12 U52.2
CF_PRESENT_N: U15.J12 U52.9
CF_REG: U15.K13 U52.4
CF_RESET_N: U15.H12 U52.7
CLK_25MHZ: U11.127 Y4.4
CLK_DIV_A: J55.2 R74.2 U10.5
CLK_DIV_B: J56.2 R75.2 U10.6
CLK_EN1: R172.1 U32.3 Y3.1
CLK_EN2: R159.1 U18.3 Y2.1
CLK_FROM_SCRUZ: J78.13 U15.B15
CLK_MR: C745.2 R225.2 U10.32
CLK_OUT_B: J47.1(OUTPUT) U10.19
CLK_SOURCE1: U32.6 Y3.3
CLK_SOURCE2: U18.6 Y2.3
CLK_TO_SCRUZ: J78.11 U15.AL18
COMP: C82.1 R117.2 U14.2
CRC_ERROR: U15.AF20
DATA_GEN_CLK_INN: C30.1 J29.1(OUTPUT)
DATA_GEN_CLK_INP: C31.1 J30.1(OUTPUT)
DEV1_CDONE_N: U19.13 U29.60
DEV1_CONFIG_N: U19.14 U29.16
DEV1_D0: R277.2 U19.16
DEV1_D1: R275.2 U19.17
DEV1_D2: R272.2 U19.18
DEV1_D3: R273.2 U19.19
DEV1_D4: R150.2 U20.2
DEV1_D5: R151.2 U20.3
DEV1_D6: R152.2 U20.4
DEV1_D7: R153.2 U20.5
DEV1_DCLK: U19.12 U29.11
DEV1_STATUS_N: U19.15 U29.23
DEV2_CDONE_N: U21.13 U30.60
DEV2_CONFIG_N: U21.14 U30.16
DEV2_D<0>: R276.2 U21.16
DEV2_D<1>: R274.2 U21.17
DEV2_D<2>: R270.2 U21.18
DEV2_D<3>: R271.2 U21.19
DEV2_D<4>: R154.2 U20.6
DEV2_D<5>: R155.2 U20.7
DEV2_D<6>: R156.2 U20.8
DEV2_D<7>: R157.2 U20.9
DEV2_DCLK: U21.12 U30.11
DEV2_STATUS_N: U21.15 U30.23
DH: U14.8 U17.2
DIFF_RX_DRSCLK_N: J109.8H U7.Y3
DIFF_RX_DRSCLK_P: J109.8G U7.Y2
DIFF_RX_DRSTAT_N0: J109.10H U7.AH14
DIFF_RX_DRSTAT_N1: J109.9H U7.AH13
DIFF_RX_DRSTAT_P0: J109.10G U7.AG16
DIFF_RX_DRSTAT_P1: J109.9G U7.AH5
DIFF_RX_N<0>: J57.A1 J108.10D U7.Y31
DIFF_RX_N<1>: J57.A2 J108.9H U7.Y29
DIFF_RX_N<2>: J57.A4 J108.9D U7.W32
DIFF_RX_N<3>: J57.A5 J108.10F U7.V31
DIFF_RX_N<4>: J57.A7 J108.10B U7.AJ32
DIFF_RX_N<5>: J57.A8 J108.9F U7.AH32
DIFF_RX_N<6>: J57.A10 J108.8F U7.AH30
DIFF_RX_N<7>: J57.A11 J108.8D U7.AG32
DIFF_RX_N<8>: J57.A15 J108.7F U7.AG30
DIFF_RX_N<9>: J57.A16 J108.8B U7.AF32
DIFF_RX_N<10>: J57.A18 J108.7B U7.AF30
DIFF_RX_N<11>: J57.A19 J108.7H U7.AE32
DIFF_RX_N<12>: J57.A21 J108.6B U7.AE30
DIFF_RX_N<13>: J57.A22 J108.6D U7.AD32
DIFF_RX_N<14>: J57.A24 J108.7D U7.AC32
DIFF_RX_N<15>: J57.A25 J108.6H U7.AB32
DIFF_RX_P<0>: J57.B1 J108.10C U7.Y30
DIFF_RX_P<1>: J57.B2 J108.9G U7.Y28
DIFF_RX_P<2>: J57.B4 J108.9C U7.W31
DIFF_RX_P<3>: J57.B5 J108.10E U7.V30
DIFF_RX_P<4>: J57.B7 J108.10A U7.AJ31
DIFF_RX_P<5>: J57.B8 J108.9E U7.AH31
DIFF_RX_P<6>: J57.B10 J108.8E U7.AH29
DIFF_RX_P<7>: J57.B11 J108.8C U7.AG31
DIFF_RX_P<8>: J57.B15 J108.7E U7.AG29
DIFF_RX_P<9>: J57.B16 J108.8A U7.AF31
DIFF_RX_P<10>: J57.B18 J108.7A U7.AF29
DIFF_RX_P<11>: J57.B19 J108.7G U7.AE31
DIFF_RX_P<12>: J57.B21 J108.6A U7.AE29
DIFF_RX_P<13>: J57.B22 J108.6C U7.AD31
DIFF_RX_P<14>: J57.B24 J108.7C U7.AC31
DIFF_RX_P<15>: J57.B25 J108.6G U7.AB31
DIFF_RX_RCTL_N: J108.6F U7.AB30
DIFF_RX_RCTL_P: J108.6E U7.AB29
DIFF_RX_RDCLK_N: J57.A13 J108.9B R61.1
DIFF_RX_RDCLK_P: J57.B13 J108.9A R61.2
DIFF_RX_RSCLK: J108.8G U7.AM8
DIFF_RX_RSTAT<0>: J108.10H U7.AM7
DIFF_RX_RSTAT<1>: J108.10G U7.AM6
DIFF_TX_DTSCLK_N: J109.5B
DIFF_TX_DTSCLK_P: J109.5A
DIFF_TX_DTSTAT_N0: J109.2D U7.Y11
DIFF_TX_DTSTAT_N1: J109.1D U7.AB12
DIFF_TX_DTSTAT_P0: J109.2C U7.Y10
DIFF_TX_DTSTAT_P1: J109.1C U7.AD10
DIFF_TX_N<0>: J58.A1 J108.2H U7.T28
DIFF_TX_N<1>: J58.A2 J108.1D U7.T23
DIFF_TX_N<2>: J58.A4 J108.1B U7.R29
DIFF_TX_N<3>: J58.A5 J108.1F U7.R27
DIFF_TX_N<4>: J58.A7 J108.3F U7.R25
DIFF_TX_N<5>: J58.A8 J108.1H U7.R23
DIFF_TX_N<6>: J58.A10 J108.3B U7.P29
DIFF_TX_N<7>: J58.A11 J108.2B U7.P27
DIFF_TX_N<8>: J58.A15 J108.4H U7.N27
DIFF_TX_N<9>: J58.A16 J108.2F U7.N25
DIFF_TX_N<10>: J58.A18 J108.4B U7.N23
DIFF_TX_N<11>: J58.A19 J108.4D U7.M27
DIFF_TX_N<12>: J58.A21 J108.4F U7.M25
DIFF_TX_N<13>: J58.A22 J108.5F U7.M23
DIFF_TX_N<14>: J58.A24 J108.3D U7.L26
DIFF_TX_N<15>: J58.A25 J108.5H U7.L24
DIFF_TX_P<0>: J58.B1 J108.2G U7.T27
DIFF_TX_P<1>: J58.B2 J108.1C U7.T22
DIFF_TX_P<2>: J58.B4 J108.1A U7.R28
DIFF_TX_P<3>: J58.B5 J108.1E U7.R26
DIFF_TX_P<4>: J58.B7 J108.3E U7.R24
DIFF_TX_P<5>: J58.B8 J108.1G U7.R22
DIFF_TX_P<6>: J58.B10 J108.3A U7.P28
DIFF_TX_P<7>: J58.B11 J108.2A U7.P26
DIFF_TX_P<8>: J58.B15 J108.4G U7.N26
DIFF_TX_P<9>: J58.B16 J108.2E U7.N24
DIFF_TX_P<10>: J58.B18 J108.4A U7.N22
DIFF_TX_P<11>: J58.B19 J108.4C U7.M26
DIFF_TX_P<12>: J58.B21 J108.4E U7.M24
DIFF_TX_P<13>: J58.B22 J108.5E U7.M22
DIFF_TX_P<14>: J58.B24 J108.3C U7.L25
DIFF_TX_P<15>: J58.B25 J108.5G U7.L23
DIFF_TX_TCTL_N: J108.5D U7.K27
DIFF_TX_TCTL_P: J108.5C U7.K26
DIFF_TX_TDCLK_N: J58.A13 J108.3H U7.P25
DIFF_TX_TDCLK_P: J58.B13 J108.3G U7.P24
DIFF_TX_TSCLK: J108.5A U7.AM9
DIFF_TX_TSTAT<0>: J108.2D U7.AE13
DIFF_TX_TSTAT<1>: J108.2C U7.AB13
DIMM_ODT0: XU2.195
DIVIDE_BY_20_LVPECL_OUT_N: J37.1(OUTPUT) R40.2 R43.1 U6.12(_FWSL_Q3)
DIVIDE_BY_20_LVPECL_OUT_P: J43.1(OUTPUT) R43.2 R48.1 U6.13
DIVIDE_BY_20_LVTTL_OUT: J49.1(OUTPUT) R52.2
DL: U14.6 U17.4
DPA_RX_N<0>: J89.1(OUTPUT) U7.R31
DPA_RX_N<1>: J100.1(OUTPUT) U7.P32
DPA_RX_P<0>: J84.1(OUTPUT) U7.R30
DPA_RX_P<1>: J95.1(OUTPUT) U7.P31
DPA_TX_N<0>: J94.1(OUTPUT) U7.Y27
DPA_TX_N<1>: J102.1(OUTPUT) U7.Y23
DPA_TX_P<0>: J99.1(OUTPUT) U7.Y26
DPA_TX_P<1>: J106.1(OUTPUT) U7.Y22
DPACLK_IN_N: J107.1(OUTPUT)
DPACLK_IN_P: J103.1(OUTPUT)
DPACLK_OUT_N: J88.1(OUTPUT) U7.Y25
DPACLK_OUT_P: J83.1(OUTPUT) U7.Y24
EN_CONFIG_DEV_N: R145.1 U19.29 U20.39 U21.29
EN_PS_MODE_N: R51.1 U19.39
EPC16_TDI: U29.42
EXT_CLK1: J104.1(OUTPUT) R176.2 U32.4
EXT_CLK2: J91.1(OUTPUT) R177.2 U18.4
EXT_CLK_IN_N: J62.1(OUTPUT) R86.2 U10.4
EXT_CLK_IN_P: J61.1(OUTPUT) R86.1 U10.3
FLASH_A<0>: U15.AD31 U29.65 U29.75 U31.25
FLASH_A<1>: U15.AD32 U29.56 U29.62 U31.24
FLASH_A<2>: U15.AC31 U29.55 U31.23
FLASH_A<3>: U15.AB32 U29.54 U31.22
FLASH_A<4>: U15.AB26 U29.53 U31.21
FLASH_A<5>: U15.AA24 U29.52 U31.20
FLASH_A<6>: U15.AG29 U29.51 U31.19
FLASH_A<7>: U15.AG30 U29.50 U31.18
FLASH_A<8>: U15.AG32 U29.34 U31.8
FLASH_A<9>: U15.AG31 U29.32 U31.7
FLASH_A<10>: U15.AF29 U29.31 U31.6
FLASH_A<11>: U15.AF30 U29.29 U31.5
FLASH_A<12>: U15.AF31 U29.28 U31.4
FLASH_A<13>: U15.AF32 U29.27 U31.3
FLASH_A<14>: U15.AE29 U29.26 U31.2
FLASH_A<15>: U15.AE30 U29.21 U29.25 U31.1
FLASH_A<16>: U15.AE31 U29.6 U29.17 U31.48
FLASH_A<17>: U15.AE32 U29.49 U31.17
FLASH_A<18>: U15.AD29 U29.47 U31.16
FLASH_A<19>: U15.AD30 U29.46 U31.9
FLASH_A<20>: U15.AC30 U29.36 U31.10
FLASH_A<21>: U15.AC29 U31.13
FLASH_BYTEN: R233.1 U15.Y24 U31.47
FLASH_CEN: R231.1 U15.AA26 U31.26
FLASH_D<0>: U15.AF25 U29.81 U31.29
FLASH_D<1>: U15.AF26 U29.83 U31.31
FLASH_D<2>: U15.AF28 U29.86 U31.33
FLASH_D<3>: U15.AF27 U29.89 U31.35
FLASH_D<4>: U15.AE26 U29.93 U31.38
FLASH_D<5>: U15.AE25 U29.95 U31.40
FLASH_D<6>: U15.AE27 U29.98 U31.42
FLASH_D<7>: U15.AE28 U29.100 U31.44
FLASH_D<8>: U15.AD25 U29.82 U31.30
FLASH_D<9>: U15.AD26 U29.85 U31.32
FLASH_D<10>: U15.AD27 U29.87 U31.34
FLASH_D<11>: U15.AD28 U29.90 U31.36
FLASH_D<12>: U15.AC28 U29.94 U31.39
FLASH_D<13>: U15.AC27 U29.97 U31.41
FLASH_D<14>: U15.AC26 U29.99 U31.43
FLASH_D<15>: U15.AC25 U29.1 U31.45
FLASH_OEN: R232.1 U15.AB27 U31.28
FLASH_RDY_BSYN: R360.2 U31.15
FLASH_RESETN: R280.1 U15.AA25 U31.12
FLASH_WEN: R281.1 U15.AA27 U31.11
FLASH_WPN: R279.1 U31.14(WP_ACC)
GLOBAL_RST_LED: RN22.3 U34.19
GLOBAL_RST_N: R149.1 RN20.14 U19.26 U19.36 U21.26 U34.30 U43.15
GLOBAL_RST_N_IN: C657.1 R149.2 R175.1 U43.1
GX_A_A: RN36.1 U25.12
GX_A_B: RN35.1 U25.23
GX_ALERTN: U5.11 U15.L14
GX_B_A: RN36.2 U25.11
GX_B_B: RN35.2 U25.22
GX_C_A: RN36.3 U25.9
GX_C_B: RN35.3 U25.20
GX_CDONE_BUF_N: R144.1 R179.1 U19.37 U21.27
GX_CDONE_N: U19.3
GX_CONFIG_BUF_N: R42.1
GX_D_A: RN36.4 U25.8
GX_D_B: RN35.4 U25.19
GX_DATA0: U19.34 U21.24
GX_DATA1: U21.23
GX_DATA2: U21.22
GX_DATA3: U21.21
GX_DATA4: U20.34
GX_DATA5: U20.33
GX_DATA6: U20.32
GX_DATA7: U20.31
GX_DCLK_BUF: R142.1 U21.28
GX_DEV_CLR_LED: RN22.1 U34.22
GX_DIG_1_A: RN15.16 U7.AJ8 U25.37
GX_DIG_1_B: RN15.15 U7.AK10 U25.38
GX_DIG_1_C: RN15.14 U7.AK11 U25.40
GX_DIG_1_D: RN15.13 U7.AK12 U25.41
GX_DIG_1_DP: RN15.9(2) U7.AK6 U25.47
GX_DIG_1_E: RN15.12 U7.AK13 U25.43
GX_DIG_1_F: RN15.11 U7.AK4 U25.44
GX_DIG_1_G: RN15.10 U7.AK5 U25.46
GX_DIG_2_A: RN16.16 U7.AJ10 U25.26
GX_DIG_2_B: RN16.15 U7.AJ11 U25.27
GX_DIG_2_C: RN16.14 U7.AJ12 U25.29
GX_DIG_2_D: RN16.13 U7.AJ13 U25.30
GX_DIG_2_DP: RN16.9(2) U7.AJ7 U25.36
GX_DIG_2_E: RN16.12 U7.AJ14 U25.32
GX_DIG_2_F: RN16.11 U7.AJ5 U25.33
GX_DIG_2_G: RN16.10 U7.AJ6 U25.35
GX_DIP<0>: RN37.14 U7.AJ21
GX_DIP<1>: RN37.13 U7.AJ20
GX_DIP<2>: RN37.12 U7.AJ19
GX_DIP<3>: RN37.11 U7.AH28
GX_DIP<4>: RN37.9(2) U7.AH26
GX_DIP<5>: RN38.15 U7.AH25
GX_DIP<6>: RN38.13 U7.AH24
GX_DIP<7>: RN38.11 U7.AH22
GX_DP_A: RN36.8 U25.2
GX_DP_B: RN35.8 U25.13
GX_E_A: RN36.5 U25.6
GX_E_B: RN35.5 U25.17
GX_EPC16_CEN: U15.AE13 U30.78
GX_EPC16_OEN: U15.AC13 U30.80
GX_EPC16_RPN: U15.AG12 U30.39 U30.72
GX_EPC16_WEN: U15.AD13 U30.33 U30.38
GX_F_A: RN36.6 U25.5
GX_F_B: RN35.6 U25.16
GX_FLASH_A<0>: U15.AK4 U30.65 U30.75
GX_FLASH_A<1>: U15.AK3 U30.56 U30.62
GX_FLASH_A<2>: U15.AH5 U30.55
GX_FLASH_A<3>: U15.AJ5 U30.54
GX_FLASH_A<4>: U15.AJ4 U30.53
GX_FLASH_A<5>: U15.AM4 U30.52
GX_FLASH_A<6>: U15.AL4 U30.51
GX_FLASH_A<7>: U15.AL3 U30.50
GX_FLASH_A<8>: U15.AJ6 U30.34
GX_FLASH_A<9>: U15.AK6 U30.32
GX_FLASH_A<10>: U15.AL5 U30.31
GX_FLASH_A<11>: U15.AK7 U30.29
GX_FLASH_A<12>: U15.AM5 U30.28
GX_FLASH_A<13>: U15.AJ7 U30.27
GX_FLASH_A<14>: U15.AM6 U30.26
GX_FLASH_A<15>: U15.AL6 U30.21 U30.25
GX_FLASH_A<16>: U15.AL7 U30.6 U30.17
GX_FLASH_A<17>: U15.AJ8 U30.49
GX_FLASH_A<18>: U15.AM7 U30.47
GX_FLASH_A<19>: U15.AH9 U30.46
GX_FLASH_A<20>: U15.AM8 U30.36
GX_FLASH_D<0>: U15.AE12 U30.81
GX_FLASH_D<1>: U15.AC12 U30.83
GX_FLASH_D<2>: U15.AA12 U30.86
GX_FLASH_D<3>: U15.AD12 U30.89
GX_FLASH_D<4>: U15.AB11 U30.93
GX_FLASH_D<5>: U15.AE11 U30.95
GX_FLASH_D<6>: U15.AF10 U30.98
GX_FLASH_D<7>: U15.AG10 U30.100
GX_FLASH_D<8>: U15.AG11 U30.82
GX_FLASH_D<9>: U15.AD9 U30.85
GX_FLASH_D<10>: U15.AG9 U30.87
GX_FLASH_D<11>: U15.AC9 U30.90
GX_FLASH_D<12>: U15.AE9 U30.94
GX_FLASH_D<13>: U15.AF9 U30.97
GX_FLASH_D<14>: U15.AD14 U30.99
GX_FLASH_D<15>: U15.AB13 U30.1
GX_G_A: RN36.7 U25.3
GX_G_B: RN35.7 U25.14
GX_HEADER<0>: J53.1 U7.AM5
GX_HEADER<1>: J53.3 U7.AM4
GX_HEADER<2>: J53.5 U7.AM14
GX_HEADER<3>: J53.7 U7.AM12
GX_HEADER<4>: J53.9 U7.AM11
GX_HEADER<5>: J53.11 U7.AM10
GX_HEADER<6>: J53.13 U7.AL9
GX_HEADER<7>: J53.15 U7.AL8
GX_HEADER<8>: J53.17 U7.AL7
GX_HEADER<9>: J53.19 U7.AL6
GX_HEADER<10>: J53.20 U7.AL5
GX_HEADER<11>: J53.18 U7.AL4
GX_HEADER<12>: J53.16 U7.AL14
GX_HEADER<13>: J53.14 U7.AL13
GX_HEADER<14>: J53.12 U7.AL12
GX_HEADER<15>: J53.10 U7.AL11
GX_HEADER<16>: J53.8 U7.AL10
GX_HEADER<17>: J53.6 U7.AK9
GX_HEADER<18>: J53.4 U7.AK8
GX_HEADER<19>: J53.2 U7.AK7
GX_LED<0>: RN19.15 U7.AC16 U34.38
GX_LED<1>: RN19.16 U7.AC15 U34.37
GX_LED<2>: RN20.10 U7.AC14 U34.36
GX_LED<3>: RN20.11 U7.AC12 U34.35
GX_LED<4>: RN20.12 U7.AB16 U34.33
GX_LED<5>: RN20.13 U7.AB14 U34.32
GX_MICTOR_EP_<0>: J34.37 U7.AM28
GX_MICTOR_EP_<1>: J34.35 U7.AM27
GX_MICTOR_EP_<2>: J34.33 U7.AM26
GX_MICTOR_EP_<3>: J34.31 U7.AM25
GX_MICTOR_EP_<4>: J34.29 U7.AM24
GX_MICTOR_EP_<5>: J34.27 U7.AM23
GX_MICTOR_EP_<6>: J34.25 U7.AM22
GX_MICTOR_EP_<7>: J34.23 U7.AM21
GX_MICTOR_EP_<8>: J34.21 U7.AL29
GX_MICTOR_EP_<9>: J34.19 U7.AL28
GX_MICTOR_EP_<10>: J34.17 U7.AL27
GX_MICTOR_EP_<11>: J34.15 U7.AL26
GX_MICTOR_EP_<12>: J34.13 U7.AL25
GX_MICTOR_EP_<13>: J34.11 U7.AL24
GX_MICTOR_EP_<14>: J34.9 U7.AL23
GX_MICTOR_EP_<15>: J34.7 U7.AL22
GX_MICTOR_EP_CLK: J34.5 U7.AM29
GX_MICTOR_OP_<0>: J34.38 U7.AL20
GX_MICTOR_OP_<1>: J34.36 U7.AK29
GX_MICTOR_OP_<2>: J34.34 U7.AK28
GX_MICTOR_OP_<3>: J34.32 U7.AK27
GX_MICTOR_OP_<4>: J34.30 U7.AK26
GX_MICTOR_OP_<5>: J34.28 U7.AK25
GX_MICTOR_OP_<6>: J34.26 U7.AK24
GX_MICTOR_OP_<7>: J34.24 U7.AK23
GX_MICTOR_OP_<8>: J34.22 U7.AK22
GX_MICTOR_OP_<9>: J34.20 U7.AK21
GX_MICTOR_OP_<10>: J34.18 U7.AK20
GX_MICTOR_OP_<11>: J34.16 U7.AJ28
GX_MICTOR_OP_<12>: J34.14 U7.AJ27
GX_MICTOR_OP_<13>: J34.12 U7.AJ26
GX_MICTOR_OP_<14>: J34.10 U7.AJ25
GX_MICTOR_OP_<15>: J34.8 U7.AJ23
GX_MICTOR_OP_CLK: J34.6 U7.AL21
GX_OVERTEMPN: U5.9 U15.F13
GX_PB0_IN: C648.1 R186.2 RN14.15 U44.14
GX_PB1_IN: C649.1 R203.2 RN14.14 U44.3
GX_PB2_IN: C650.1 R208.2 RN14.12 U44.12
GX_PB3_IN: C658.1 R212.2 RN14.10 U44.5
GX_PB<0>: R186.1 U7.AD14 U44.2
GX_PB<1>: R203.1 U7.AD13 U44.13
GX_PB<2>: R208.1 U7.AD12 U44.4
GX_PB<3>: R212.1 U7.AD11 U44.11
GX_PB_DEV_CLR_N: R184.1 U34.27 U44.15
GX_PB_DEV_CLR_N_IN: C647.1 R184.2 RN14.16 U44.1
GX_PGM0: U21.6
GX_PGM1: U21.7
GX_PGM2: U21.8
GX_PLL_ENA: R57.1
GX_RECOV_CLK<0>: J5.1(OUTPUT) U7.AB17
GX_RECOV_CLK<1>: J4.1(OUTPUT) U7.AC20
GX_RECOV_CLK<2>: J2.1(OUTPUT) U7.AD23
GX_RECOV_CLK<3>: J3.1(OUTPUT) U7.AF21
GX_RECOV_CLK<4>: J6.1(OUTPUT) U7.AJ22
GX_RS232_CTS: R163.2 U7.AE11 U28.9
GX_RS232_RTS: R164.2 U7.AE14 U28.10
GX_RS232_RXD: U7.AE12 U28.12
GX_RS232_TXD: U7.AB15 U28.11
GX_RUNLU: R37.1 U20.24 U21.31
GX_RX1IN1: J124.12 U28.13
GX_RX2IN1: J124.16 U28.8
GX_SMB_CLK: U5.14 U15.H13
GX_SMB_DATA: U5.12 U15.C14
GX_STATUS_BUF_N: R143.1 U19.35 U21.25
GX_TEMPDIODEN: U5.4
GX_TEMPDIODEP: U5.3
GX_TX1OUT1: J124.11(TXD) U28.14
GX_TX2OUT1: J124.17 U28.7
GX_USER_LED1: RN21.2 U34.11
GX_USER_LED2: RN21.1 U34.12
GX_USER_LED3: RN22.7 U34.13
GX_USER_LED4: RN22.6 U34.14
GX_USER_LED5: RN22.5 U34.16
GX_USER_LED6: RN22.4 U34.17
GX_VCCSEL: R39.1
GXPGM<0>: R289.1 U20.23 U21.34 U30.14
GXPGM<1>: R290.1 U20.22 U21.33 U30.13
GXPGM<2>: R291.1 U20.21 U21.32 U30.15
HIDRV: R62.1 U37.12
LAN_A<0>: U11.78 U15.H30
LAN_A<1>: U11.79 U15.G30
LAN_A<2>: U11.80 U15.R29
LAN_A<3>: U11.81 U15.R30
LAN_A<4>: U11.82 U15.R31
LAN_A<5>: U11.83 U15.R32
LAN_A<6>: U11.84 U15.P32
LAN_A<7>: U11.85 U15.P31
LAN_A<8>: U11.86 U15.P30
LAN_A<9>: U11.87 U15.P29
LAN_A<10>: U11.88 U15.N32
LAN_A<11>: U11.89 U15.N31
LAN_A<12>: U11.90 U15.N30
LAN_A<13>: U11.91 U15.N29
LAN_A<14>: U11.92 U15.M30
LAN_ADSN: R125.1 U11.37
LAN_AEN: U11.41 U15.M29
LAN_BEN<0>: U11.94 U15.K30
LAN_BEN<1>: U11.95 U15.J30
LAN_BEN<2>: U11.96 U15.J29
LAN_BEN<3>: U11.97 U15.H32
LAN_CYCLEN: U11.35
LAN_D<0>: U11.107 U15.J26
LAN_D<1>: U11.106 U15.J25
LAN_D<2>: U11.105 U15.H26
LAN_D<3>: U11.104 U15.H25
LAN_D<4>: U11.102 U15.J28
LAN_D<5>: U11.101 U15.J27
LAN_D<6>: U11.100 U15.R24
LAN_D<7>: U11.99 U15.R23
LAN_D<8>: U11.76 U15.P26
LAN_D<9>: U11.75 U15.P25
LAN_D<10>: U11.74 U15.R27
LAN_D<11>: U11.73 U15.R28
LAN_D<12>: U11.71 U15.P27
LAN_D<13>: U11.70 U15.P28
LAN_D<14>: U11.69 U15.N26
LAN_D<15>: U11.68 U15.N25
LAN_D<16>: U11.66 U15.P24
LAN_D<17>: U11.65 U15.P23
LAN_D<18>: U11.64 U15.N28
LAN_D<19>: U11.63 U15.N27
LAN_D<20>: U11.61 U15.N23
LAN_D<21>: U11.60 U15.N24
LAN_D<22>: U11.59 U15.M25
LAN_D<23>: U11.58 U15.M24
LAN_D<24>: U11.56 U15.M27
LAN_D<25>: U11.55 U15.M26
LAN_D<26>: U11.54 U15.L26
LAN_D<27>: U11.53 U15.L27
LAN_D<28>: U11.51 U15.K25
LAN_D<29>: U11.50 U15.K26
LAN_D<30>: U11.49 U15.K27
LAN_D<31>: U11.48 U15.K28
LAN_DATACS_N: U11.34 U15.G31
LAN_ENEEP: R242.1 U11.6
LAN_INTRQ0: U11.29 U15.L30
LAN_IOCHRDY: U11.38 U15.K31
LAN_IORN: R121.1 U11.31 U15.M28
LAN_IOWN: U11.32 U15.L32
LAN_LCLK: R128.1 U11.42
LAN_LDEVN: U11.45 U15.J31
LAN_LEDA_N: RJ1.10 U11.22
LAN_LEDB_N: RJ1.12 U11.23
LAN_LOOPBACK: U11.21 U15.J32
LAN_OSC_EN: Y4.1
LAN_RBIAS: R102.1 U11.12
LAN_RDYRTNN: U11.46
LAN_RESET: U11.30 U15.L31
LAN_RXDN: R118.2 RJ1.6
LAN_RXDP: R103.2 RJ1.4
LAN_SRDY_N: U11.43 U15.G32
LAN_TXDN: R244.1 RJ1.3 U11.15
LAN_TXDP: R243.1 RJ1.1(TDP) U11.14
LAN_VLBUS_N: U11.40 U15.H29
LAN_W_RN: U11.36
LODRV: R71.1 U37.9
MAIN_PWR: ISO1.1
MAIN_SWN: J31.14
MSEL0: R53.1 U15.AG18
MSEL1: R68.1 U15.AE18
MSEL2: R130.1 U15.AE19
NET_2_I2_1: C727.1
NET_2_I12_2: C418.2 R222.1 R223.2 U38.4
NET_2_I17_1: C731.1
NET_2_I21_2: C313.1 U37.6 U37.7
NET_2_I22_2: C328.1 R215.2 U37.3
NET_2_I25_G: R62.2
NET_2_I31_2: R350.2 R351.2 U8.6
NET_2_I32_1: C307.1 U37.1
NET_2_I38_G: R71.2
NET_2_I41_1: C729.1
NET_2_I48_TP: J31.8
NET_2_I52_2: C725.2 R344.2 U38.1 U38.2
NET_2_I70_VREF: C308.1 U37.20(VREF)
NET_2_I149_IN: C732.1
NET_2_I150_IN: C730.1
NET_3_I14_ADJ: R3.2 R4.2 U1.5
NET_3_I15_2: C167.1 U36.6 U36.7
NET_3_I17_IN: C733.1
NET_3_I19_2: C726.1 R185.1 R187.2 U36.16
NET_3_I22_1: C735.1
NET_3_I22_2: C736.1
NET_3_I27_1: C134.1 U36.20(VREF)
NET_3_I33_CEXT: C133.1 U36.1
NET_3_I33_HIDRV: R202.1 U36.12
NET_3_I33_LODRV: R190.1 U36.9
NET_3_I33_VCCQP: C232.1 R301.2 U36.13
NET_3_I34_1: C42.1 C238.1 C239.1
NET_3_I37_2: C734.1
NET_3_I41_2: R202.2
NET_3_I46_2: R190.2
NET_3_I121_2: C147.1 R189.2 U36.3
NET_4_I14_2: R5.2 R6.2 U2.1
NET_4_I17_1: C718.1 R324.2
NET_4_I18_1: C700.1 R327.1 U53.8(VTT)
NET_4_I18_2: R327.2 R329.2 U53.3
NET_4_I48_1: C715.1
NET_5_I2_Q1: U46.6
NET_5_I20_Q0: J80.1(OUTPUT) U47.7
NET_5_I20_Q1: U47.6
NET_6_I12_1: J76.1(OUTPUT) R126.1
NET_6_I12_2: R126.2 R127.2 U13.3
NET_6_I15_2: R28.1 R32.2 U6.3
NET_6_I16_2: R47.2 R214.1 U6.15 U9.2
NET_6_I17_1: R52.1 U9.7
NET_6_I19_OUTPUT: J46.1(OUTPUT) U10.26
NET_6_I20_2: R46.2 R214.2 U6.14 U9.3(_FWSL_D)
NET_6_I21_1: C790.1 R361.1 U60.1 U60.3
NET_6_I25_D: C31.2 R18.2 R19.1 U4.2
NET_6_I25_FWSLD: C30.2 R17.2 R18.1 U4.3(_FWSL_D)
NET_6_I25_Q0: R33.2 R35.2 U4.7 U6.4
NET_6_I25_Q1: R27.2 R33.1 U4.6 U6.5
NET_6_I25_RST: R21.2 U4.1
NET_6_I26_2: R31.1 R34.2 U6.9
NET_6_I33_ADJ: C775.2 R354.1 R357.1 U60.4
NET_6_I43_VCC: C659.2 C777.1 R355.1 U9.8
NET_6_I48_1: R260.1 Y1.1
NET_6_I80_1: R127.1 Y1.3
NET_7_I12_BASE: R179.2
NET_7_I12_EMITTER: R141.1
NET_7_I14_7: J48.2
NET_7_I19_DATA0: R277.1 U29.73
NET_7_I19_DATA1: R275.1 U29.84
NET_7_I19_DATA2: R272.1 U29.88
NET_7_I19_DATA3: R273.1 U29.91
NET_7_I19_DATA4: R150.1 U29.96
NET_7_I19_DATA5: R151.1 U29.10
NET_7_I19_DATA6: R152.1 U29.9
NET_7_I19_DATA7: R153.1 U29.8
NET_7_I19_PORSEL: R278.2 U29.66
NET_7_I52_1: R139.1
NET_7_I77_1: R178.1
NET_8_I16_1: R154.1 U30.96
NET_8_I17_1: R274.1 U30.84
NET_8_I20_1: R271.1 U30.91
NET_8_I25_DATA0: R276.1 U30.73
NET_8_I25_DATA2: R270.1 U30.88
NET_8_I25_DATA5: R155.1 U30.10
NET_8_I25_DATA6: R156.1 U30.9
NET_8_I25_DATA7: R157.1 U30.8
NET_9_I26_1: PMCJN2.2(TRSTN) R98.1
NET_14_I26_1: C81.1 R117.1
NET_14_I36_2: R247.2 R248.2 U14.3
NET_14_I103_D1A: C92.2 U14.9 U17.1(S2) U17.5 U17.6
NET_20_I1_2: C280.1 R204.2 U5.1(VCC) U5.15
NET_22_I11_1: C90.1 R124.2 U12.1(VCC) U12.15
NET_22_I15_PLL6OUT0P: R349.1 U15.AL16
NET_23_I13_1: C638.1 R261.1
NET_27_I13_1: C703.1 U44.7
NET_27_I13_2: C703.2 U44.9
NET_27_I21_OSCIN: C702.1 U43.7
NET_27_I21_OSCOUT: C702.2 U43.9
NET_28_I4_1: C113.1 U28.1
NET_28_I4_2: C113.2 U28.3
NET_28_I10_1: C116.1 U33.6
NET_28_I11_1: C112.1 U28.5
NET_28_I11_2: C112.2 U28.4
NET_28_I12_DCE: J124.10 J124.13 J124.15
NET_28_I14_1: C118.1 U33.1
NET_28_I14_2: C118.2 U33.3
NET_28_I15_1: C111.1 U28.6
NET_28_I16_1: C119.1 U33.2
NET_28_I17_1: C117.1 U33.5
NET_28_I17_2: C117.2 U33.4
NET_28_I18_1: C114.1 U28.2
NET_29_I15_2: RN34.10
NET_30_I1_2: RN21.9(2)
NET_30_I10_2: RN22.12
NET_30_I12_2: R285.2 U34.1
NET_30_I13_2: R283.2 U34.48
NET_30_I14_2: RN21.10
NET_30_I16_2: R282.2 U34.25
NET_30_I20_CATHODE: RN21.13
NET_30_I21_CATHODE: RN22.15
NET_30_I22_2: RN22.16
NET_30_I24_CATHODE: RN21.12
NET_30_I25_CATHODE: RN21.14
NET_30_I26_CATHODE: RN22.13
NET_30_I31_2: RN22.11
NET_30_I33_CATHODE: RN21.11
NET_30_I35_2: RN21.16
NET_30_I38_2: R284.2 U34.24
NET_30_I39_2: RN22.10
NET_30_I40_2: RN22.14
NET_30_I43_CATHODE: RN21.15
NET_42_I1_1: C774.1 R352.2 U59.6
NET_42_I14_1: R353.1 U59.1
NIO_PULLUP: U15.AF15
PARALLELBUS_ADDR<0>: RN27.5 U7.K20 XU2.188
PARALLELBUS_ADDR<1>: RN27.7 U7.L19 XU2.183
PARALLELBUS_ADDR<2>: RN27.6 U7.K19 XU2.63
PARALLELBUS_ADDR<3>: RN29.1 U7.J19 XU2.182
PARALLELBUS_ADDR<4>: RN29.2 U7.L18 XU2.61
PARALLELBUS_ADDR<5>: RN29.3 U7.K18 XU2.60
PARALLELBUS_ADDR<6>: RN29.4 U7.L15 XU2.180
PARALLELBUS_ADDR<7>: RN29.6 U7.J14 XU2.58
PARALLELBUS_ADDR<8>: RN29.5 U7.K14 XU2.179
PARALLELBUS_ADDR<9>: RN29.8 U7.L14 XU2.177
PARALLELBUS_ADDR<10>: RN27.3 U7.K21 XU2.70
PARALLELBUS_ADDR<11>: RN29.7 U7.H11 XU2.57
PARALLELBUS_ADDR<12>: R136.2 U7.H14 XU2.176
PARALLELBUS_ADDR<13>: RN27.1 U7.L20 XU2.196
PARALLELBUS_ADDR<14>: RN5.8 U7.H13 XU2.174
PARALLELBUS_ADDR<15>: U7.J11 XU2.173
PARALLELBUS_BA<0>: RN27.2 U7.G20 XU2.71
PARALLELBUS_BA<1>: RN27.4 U7.J20 XU2.190
PARALLELBUS_BA<2>: U7.K13 XU2.54
PARALLELBUS_CAS_N: RN5.3 XU2.74
PARALLELBUS_CASN: U7.H22
PARALLELBUS_CB<0>: U7.E13 XU2.42
PARALLELBUS_CB<1>: U7.D13 XU2.43
PARALLELBUS_CB<2>: U7.D14 XU2.48
PARALLELBUS_CB<3>: U7.F15 XU2.49
PARALLELBUS_CB<4>: U7.G13 XU2.161
PARALLELBUS_CB<5>: U7.F13 XU2.162
PARALLELBUS_CB<6>: U7.A14 XU2.167
PARALLELBUS_CB<7>: U7.B14 XU2.168
PARALLELBUS_CLK0_N: U7.C15 XU2.186
PARALLELBUS_CLK0_P: U7.B15 XU2.185
PARALLELBUS_CLK1_N: U7.D16 XU2.138
PARALLELBUS_CLK1_P: U7.C16 XU2.137
PARALLELBUS_CLK2_N: U7.E15 XU2.221
PARALLELBUS_CLK2_P: U7.D15 XU2.220
PARALLELBUS_CLK_EN<0>: R76.2 RN5.4 U7.L13 XU2.52
PARALLELBUS_CLK_EN<1>: R77.2 RN5.5 U7.K12 XU2.171
PARALLELBUS_CS0_N: RN5.6 U7.J21 XU2.76
PARALLELBUS_CS1_N: RN5.7 U7.K22
PARALLELBUS_CSN0: XU2.193
PARALLELBUS_DATA<0>: RN32.14 U7.D6 XU2.3
PARALLELBUS_DATA<1>: RN32.13 U7.D5 XU2.4
PARALLELBUS_DATA<2>: RN32.10 U7.A4 XU2.9
PARALLELBUS_DATA<3>: RN32.9(2) U7.A5 XU2.10
PARALLELBUS_DATA<4>: RN32.16 U7.E5 XU2.122
PARALLELBUS_DATA<5>: RN32.15 U7.C6 XU2.123
PARALLELBUS_DATA<6>: RN32.12 U7.B4 XU2.128
PARALLELBUS_DATA<7>: RN32.11 U7.A6 XU2.129
PARALLELBUS_DATA<8>: RN31.14 U7.E6 XU2.12
PARALLELBUS_DATA<9>: RN31.13 U7.A7 XU2.13
PARALLELBUS_DATA<10>: RN31.10 U7.A8 XU2.21
PARALLELBUS_DATA<11>: RN31.9(2) U7.C9 XU2.22
PARALLELBUS_DATA<12>: RN31.16 U7.E7 XU2.131
PARALLELBUS_DATA<13>: RN31.15 U7.B7 XU2.132
PARALLELBUS_DATA<14>: RN31.12 U7.C8 XU2.140
PARALLELBUS_DATA<15>: RN31.11 U7.A9 XU2.141
PARALLELBUS_DATA<16>: RN30.14 U7.F8 XU2.24
PARALLELBUS_DATA<17>: RN30.13 U7.F10 XU2.25
PARALLELBUS_DATA<18>: RN30.10 U7.B10 XU2.30
PARALLELBUS_DATA<19>: RN30.9(2) U7.D10 XU2.31
PARALLELBUS_DATA<20>: RN30.16 U7.E8 XU2.143
PARALLELBUS_DATA<21>: RN30.15 U7.D8 XU2.144
PARALLELBUS_DATA<22>: RN30.12 U7.D11 XU2.149
PARALLELBUS_DATA<23>: RN30.11 U7.A10 XU2.150
PARALLELBUS_DATA<24>: RN28.14 U7.G11 XU2.33
PARALLELBUS_DATA<25>: RN28.13 U7.A11 XU2.34
PARALLELBUS_DATA<26>: RN28.10 U7.E11 XU2.39
PARALLELBUS_DATA<27>: RN28.9(2) U7.D12 XU2.40
PARALLELBUS_DATA<28>: RN28.16 U7.G10 XU2.152
PARALLELBUS_DATA<29>: RN28.15 U7.B11 XU2.153
PARALLELBUS_DATA<30>: RN28.12 U7.A12 XU2.158
PARALLELBUS_DATA<31>: RN28.11 U7.G12 XU2.159
PARALLELBUS_DATA<32>: RN26.14 U7.C20 XU2.80
PARALLELBUS_DATA<33>: RN26.13 U7.B20 XU2.81
PARALLELBUS_DATA<34>: RN26.10 U7.A22 XU2.86
PARALLELBUS_DATA<35>: RN26.9(2) U7.C22 XU2.87
PARALLELBUS_DATA<36>: RN26.16 U7.E19 XU2.199
PARALLELBUS_DATA<37>: RN26.15 U7.E20 XU2.200
PARALLELBUS_DATA<38>: RN26.12 U7.C21 XU2.205
PARALLELBUS_DATA<39>: RN26.11 U7.A21 XU2.206
PARALLELBUS_DATA<40>: RN25.14 U7.A23 XU2.89
PARALLELBUS_DATA<41>: RN25.13 U7.C23 XU2.90
PARALLELBUS_DATA<42>: RN25.10 U7.D23 XU2.95
PARALLELBUS_DATA<43>: RN25.9(2) U7.F23 XU2.96
PARALLELBUS_DATA<44>: RN25.16 U7.F22 XU2.208
PARALLELBUS_DATA<45>: RN25.15 U7.D21 XU2.209
PARALLELBUS_DATA<46>: RN25.12 U7.C24 XU2.214
PARALLELBUS_DATA<47>: RN25.11 U7.A24 XU2.215
PARALLELBUS_DATA<48>: RN24.14 U7.A26 XU2.98
PARALLELBUS_DATA<49>: RN24.13 U7.C25 XU2.99
PARALLELBUS_DATA<50>: RN24.10 U7.E26 XU2.107
PARALLELBUS_DATA<51>: RN24.9(2) U7.E27 XU2.108
PARALLELBUS_DATA<52>: RN24.16 U7.E24 XU2.217
PARALLELBUS_DATA<53>: RN24.15 U7.A25 XU2.218
PARALLELBUS_DATA<54>: RN24.12 U7.D26 XU2.226
PARALLELBUS_DATA<55>: RN24.11 U7.C26 XU2.227
PARALLELBUS_DATA<56>: RN23.14 U7.A29 XU2.110
PARALLELBUS_DATA<57>: RN23.13 U7.C27 XU2.111
PARALLELBUS_DATA<58>: RN23.10 U7.D28 XU2.116
PARALLELBUS_DATA<59>: RN23.9(2) U7.E28 XU2.117
PARALLELBUS_DATA<60>: RN23.16 U7.A27 XU2.229
PARALLELBUS_DATA<61>: RN23.15 U7.A28 XU2.230
PARALLELBUS_DATA<62>: RN23.12 U7.B29 XU2.235
PARALLELBUS_DATA<63>: RN23.11 U7.D27 XU2.236
PARALLELBUS_DM<0>: U7.B5 XU2.125
PARALLELBUS_DM<1>: U7.B8 XU2.134
PARALLELBUS_DM<2>: U7.C10 XU2.146
PARALLELBUS_DM<3>: U7.C12 XU2.155
PARALLELBUS_DM<4>: U7.B21 XU2.202
PARALLELBUS_DM<5>: U7.B23 XU2.211
PARALLELBUS_DM<6>: U7.D25 XU2.223
PARALLELBUS_DM<7>: U7.C28 XU2.232
PARALLELBUS_DM<8>: U7.C13 XU2.164
PARALLELBUS_ODT<0>: U7.E25
PARALLELBUS_ODT<1>: U7.L21 XU2.77
PARALLELBUS_RAS_N: RN5.2 U7.G21
PARALLELBUS_RASN: XU2.192
PARALLELBUS_REF_CLK_SMA: U7.E16
PARALLELBUS_RESET_N: U7.E22 XU2.18
PARALLELBUS_SCL: U7.B28 XU2.120
PARALLELBUS_SDA: U7.J22 XU2.119
PARALLELBUS_STROBE<0>: R238.1 U7.C4 XU2.7
PARALLELBUS_STROBE<1>: R236.1 U7.D7 XU2.16
PARALLELBUS_STROBE<2>: R73.1 U7.F9 XU2.28
PARALLELBUS_STROBE<3>: R70.1 U7.F11 XU2.37
PARALLELBUS_STROBE<4>: R30.1 U7.D19 XU2.84
PARALLELBUS_STROBE<5>: R23.1 U7.D22 XU2.93
PARALLELBUS_STROBE<6>: R11.1 U7.B25 XU2.105
PARALLELBUS_STROBE<7>: R7.1 U7.B27 XU2.114
PARALLELBUS_SYNC_CLK: U7.B13 U7.T30
PARALLELBUS_WE_N: RN5.1 U7.G22 XU2.73
PGM_DIP: R146.1 U20.29
PGM_REMOTE: R147.1 U21.39
PMC_AD<0>: PMCJN1.61 U15.H22
PMC_AD<1>: PMCJN1.60 U15.E22
PMC_AD<2>: PMCJN1.59 U15.D22
PMC_AD<3>: PMCJN1.58 U15.C22
PMC_AD<4>: PMCJN1.55 U15.B22
PMC_AD<5>: PMCJN1.54 U15.A22
PMC_AD<6>: PMCJN1.53 U15.L23
PMC_AD<7>: PMCJN2.51 U15.K23
PMC_AD<8>: PMCJN2.49 U15.H23
PMC_AD<9>: PMCJN1.49 U15.G23
PMC_AD<10>: PMCJN2.48 U15.F23
PMC_AD<11>: PMCJN1.48 U15.D23
PMC_AD<12>: PMCJN1.47 U15.C23
PMC_AD<13>: PMCJN2.46 U15.L24
PMC_AD<14>: PMCJN2.45 U15.K24
PMC_AD<15>: PMCJN1.46 U15.J24
PMC_AD<16>: PMCJN2.25 PMCJN2.31 U15.A25
PMC_AD<17>: PMCJN1.32 U15.B27 U15.F26
PMC_AD<18>: PMCJN2.29 U15.E26
PMC_AD<19>: PMCJN1.29 U15.D26
PMC_AD<20>: PMCJN2.28 U15.C26
PMC_AD<21>: PMCJN1.28 U15.B26
PMC_AD<22>: PMCJN1.27 U15.D27
PMC_AD<23>: PMCJN2.26 U15.C27
PMC_AD<24>: PMCJN2.23 U15.E28
PMC_AD<25>: PMCJN1.23 U15.D28
PMC_AD<26>: PMCJN2.22 U15.C28
PMC_AD<27>: PMCJN1.22 U15.B28
PMC_AD<28>: PMCJN1.21 U15.A28
PMC_AD<29>: PMCJN2.20 U15.D29
PMC_AD<30>: PMCJN2.19 U15.C29
PMC_AD<31>: PMCJN1.20 U15.B29
PMC_BUSMODEN<1>: PMCJN1.7 U15.L20
PMC_BUSMODEN<2>: PMCJN2.11 U15.J21
PMC_BUSMODEN<3>: PMCJN2.14 U15.K21
PMC_BUSMODEN<4>: PMCJN2.16 U15.L21
PMC_C_BEN<0>: PMCJN1.52 U15.J23
PMC_C_BEN<1>: PMCJN2.43 U15.G24
PMC_C_BEN<2>: PMCJN2.32 U15.B25
PMC_C_BEN<3>: PMCJN1.26 U15.A27
PMC_CLK: PMCJN1.13 R349.2
PMC_DEVSELN: PMCJN1.37 R67.1 U15.B24
PMC_FRAMEN: PMCJN1.33 U15.C25
PMC_GNTN: PMCJN1.16 U15.B20
PMC_INTAN: PMCJN1.4 R80.1 U15.A29
PMC_INTBN: PMCJN1.5 R65.1 U15.K18
PMC_INTCN: PMCJN1.6 R81.1 U15.F19
PMC_INTDN: PMCJN1.9 R66.1 U15.F20
PMC_IRDYN: PMCJN1.36 R83.1 U15.D25
PMC_LOCKN: PMCJN1.40 R85.1 U15.H19
PMC_M66EN: PMCJN2.47 U15.H20
PMC_PAR: PMCJN1.43 U15.E24
PMC_PERRN: PMCJN2.39 R84.1 U15.D24
PMC_REQN: PMCJN1.17 U15.A20
PMC_RESETN: PMCJN2.13 U15.C19 U15.D19
PMC_SERRN: PMCJN2.42 R100.1 U15.B23
PMC_STOPN: PMCJN2.38 R99.1 U15.C24
PMC_TRDYN: PMCJN2.35 R82.1 U15.A24
PORSEL: R286.1 U15.AG15
PS_CDONE_N: J85.3
PS_CONFIG_N: J85.5 U19.4
PS_DCLK: J85.1 U19.2
PS_EPLD_D0: J85.9 U19.6 U19.7
PS_STATUS_N: J85.7 U19.5 U19.8
PWR_SW: R207.1 R216.2
Q_CF_ATASEL_N: CON3.9 U52.18
Q_CF_CS_N: CON3.32 U52.14
Q_CF_POWER: U52.22 U59.5
Q_CF_PRESENT_N: CON3.26 R318.2 U52.15
Q_CF_REG: CON3.44 U52.20
Q_CF_RESET_N: CON3.41 R319.2 U52.17
Q_SCRUZ_IO<0>: CON3.6 J92.3 U24.22
Q_SCRUZ_IO<1>: CON3.47 J92.4 U24.21
Q_SCRUZ_IO<2>: CON3.5 J92.5 U24.20
Q_SCRUZ_IO<3>: CON3.48 J92.6 U24.19
Q_SCRUZ_IO<4>: CON3.4 J92.7 U24.18
Q_SCRUZ_IO<5>: CON3.49 J92.8 U24.17
Q_SCRUZ_IO<6>: CON3.3 J92.9 U24.16
Q_SCRUZ_IO<7>: CON3.27 J92.10 U24.15
Q_SCRUZ_IO<8>: CON3.2 J92.11 U24.14
Q_SCRUZ_IO<9>: CON3.28 J92.12 U24.13
Q_SCRUZ_IO<10>: CON3.23 J92.13 U23.22
Q_SCRUZ_IO<11>: CON3.29 J92.14 U23.21
Q_SCRUZ_IO<12>: CON3.22 J92.15 U23.20
Q_SCRUZ_IO<13>: CON3.30 J92.16 U23.19
Q_SCRUZ_IO<14>: CON3.21 J92.17 U23.18
Q_SCRUZ_IO<15>: CON3.31 J92.18 U23.17
Q_SCRUZ_IO<16>: J92.21 R306.1 U23.16
Q_SCRUZ_IO<17>: CON3.35 J92.23 U23.15
Q_SCRUZ_IO<18>: CON3.34 J92.25 U23.14
Q_SCRUZ_IO<19>: CON3.42 J92.27 R305.1 U23.13
Q_SCRUZ_IO<20>: J92.28 U22.22
Q_SCRUZ_IO<21>: J92.29 U22.21
Q_SCRUZ_IO<22>: CON3.37 J92.31 R304.1 R307.1 U22.20
Q_SCRUZ_IO<23>: CON3.24 J92.32 R303.1 U22.19
Q_SCRUZ_IO<24>: CON3.19 J92.33 U22.18
Q_SCRUZ_IO<25>: CON3.20 J92.35 U22.17
Q_SCRUZ_IO<26>: CON3.18 J92.36 U22.16
Q_SCRUZ_IO<27>: CON3.7 J92.37 U22.15
Q_SCRUZ_IO<28>: CON3.45 J92.39 U22.14
Q_SCRUZ_IO<29>: CON3.8 J79.4 U22.13
Q_SCRUZ_IO<30>: CON3.46 J79.5 U39.22
Q_SCRUZ_IO<31>: CON3.10 J79.6 U39.21
Q_SCRUZ_IO<32>: CON3.11 J79.7 U39.20
Q_SCRUZ_IO<33>: CON3.12 J79.8 U39.19
Q_SCRUZ_IO<34>: CON3.14 J79.9 U39.18
Q_SCRUZ_IO<35>: CON3.15 J79.10 U39.17
Q_SCRUZ_IO<36>: CON3.16 J79.11 U39.16
Q_SCRUZ_IO<37>: CON3.17 J79.12 U39.15
Q_SCRUZ_IO<38>: CON3.36(WE_HSH_) J79.13 U39.14
Q_SCRUZ_IO<39>: CON3.43 J79.14 U39.13
RDN8: R132.1 U15.AC20
RDN_4: U7.AG24
REFCLKB14N: R342.1
REFCLKB14P: R342.2
REFCLKB15N: R343.1
REFCLKB15P: R343.2
RUNLU: J90.2 U21.5 U21.9
RUP8: R131.1 U15.AH19
RUP_4: U7.AG23
S_A_A: RN34.1 U26.12
S_A_B: RN33.1 U26.23
S_ALERTN: U12.11 U15.H14
S_B_A: RN34.2 U26.11
S_B_B: RN33.2 U26.22
S_C_A: RN34.3 U26.9
S_C_B: RN33.3 U26.20
S_CDONE_BUF_N: R133.1 R178.2 U15.G18 U19.27 U19.31
S_CDONE_N: U19.9
S_CONFIG_BUF_N: R123.1 U15.J18
S_D_A: RN34.4 U26.8
S_D_B: RN33.4 U26.19
